v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
B 2 1020 -4860 1820 -4460 {flags=graph
y1=-0.2
y2=3.5
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.16607e-09
x2=2.69117e-08
divx=5
subdivx=1
node="v(di0) v(do0) v(sel1)"
color="4 3 1"
dataset=0
unitx=n
}
B 2 1020 -4350 1820 -3950 {flags=graph
y1=-0.0109153
y2=3.01898
ypos1=-0.2
ypos2=3.5
divy=5
subdivy=1
unity=1
x1=2.16607e-09
x2=2.69117e-08
divx=5
subdivx=1
node="v(clk) v(sel1) v(xbyte2.xbyte_1.ck_o)"
color="4 3 1"
dataset=0
unitx=n
}
B 2 1960 -4860 2760 -4460 {flags=graph
y1=-0.2
y2=3.5
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.16607e-09
x2=2.69117e-08
divx=5
subdivx=1
node="v(en) v(do0)"
color="3 1"
dataset=0
unitx=n
}
T {WORD x 32} 3070 -4140 0 0 5 5 {}
T {BUF_SEL} -1030 -2050 0 0 4 4 {}
T {BUF_IN} -1000 -970 0 0 4 4 {}
T {BUF_CLK} -160 -4060 0 0 2 2 {}
T {BUF_WE} 890 -3570 0 0 2 2 {}
T {SIGNALS} -960 -4210 0 0 2 2 {}
T {DEC2to4 x1
DEC3to8 x4} -1070 -3250 0 0 3 3 {}
N 0 -3130 20 -3130 {
lab=A3}
N 0 -3110 20 -3110 {
lab=A4}
N 0 -3090 20 -3090 {
lab=EN}
N 180 -3160 190 -3160 {
lab=#net1}
N 180 -3140 190 -3140 {
lab=#net2}
N 180 -3120 190 -3120 {
lab=#net3}
N 180 -3100 190 -3100 {
lab=#net4}
N 190 -3510 190 -3160 {
lab=#net1}
N 190 -3510 440 -3510 {
lab=#net1}
N 220 -3260 440 -3260 {
lab=#net2}
N 220 -3260 220 -3140 {
lab=#net2}
N 190 -3140 220 -3140 {
lab=#net2}
N 220 -3010 440 -3010 {
lab=#net3}
N 220 -3120 220 -3010 {
lab=#net3}
N 190 -3120 220 -3120 {
lab=#net3}
N 190 -3100 190 -2750 {
lab=#net4}
N 190 -2750 440 -2750 {
lab=#net4}
N 360 -3490 440 -3490 {
lab=A2}
N 360 -3490 360 -2730 {
lab=A2}
N 360 -2730 440 -2730 {
lab=A2}
N 360 -2990 440 -2990 {
lab=A2}
N 360 -3240 440 -3240 {
lab=A2}
N 380 -3470 440 -3470 {
lab=A1}
N 320 -3470 380 -3470 {
lab=A1}
N 320 -3470 320 -2710 {
lab=A1}
N 320 -2710 440 -2710 {
lab=A1}
N 320 -2970 440 -2970 {
lab=A1}
N 320 -3220 440 -3220 {
lab=A1}
N 280 -3450 440 -3450 {
lab=A0}
N 280 -3450 280 -2690 {
lab=A0}
N 280 -2690 440 -2690 {
lab=A0}
N 280 -3200 440 -3200 {
lab=A0}
N 280 -2950 440 -2950 {
lab=A0}
N 0 -2990 360 -2990 {
lab=A2}
N 0 -2970 320 -2970 {
lab=A1}
N 0 -2950 280 -2950 {
lab=A0}
N 430 -3570 440 -3570 {
lab=VDD}
N 430 -3550 440 -3550 {
lab=VSS}
N 430 -3320 440 -3320 {
lab=VDD}
N 430 -3300 440 -3300 {
lab=VSS}
N 430 -3070 440 -3070 {
lab=VDD}
N 430 -3050 440 -3050 {
lab=VSS}
N 430 -2810 440 -2810 {
lab=VDD}
N 430 -2790 440 -2790 {
lab=VSS}
N 10 -3170 20 -3170 {
lab=VDD}
N 10 -3150 20 -3150 {
lab=VSS}
N 430 -3570 440 -3570 {
lab=VDD}
N 430 -3550 440 -3550 {
lab=VSS}
N 430 -3320 440 -3320 {
lab=VDD}
N 430 -3300 440 -3300 {
lab=VSS}
N 430 -3070 440 -3070 {
lab=VDD}
N 430 -3050 440 -3050 {
lab=VSS}
N 430 -2810 440 -2810 {
lab=VDD}
N 430 -2790 440 -2790 {
lab=VSS}
N 160 -2470 180 -2470 {
lab=#net5}
N 80 -2510 240 -2510 {
lab=VDD}
N 80 -2430 240 -2430 {
lab=VSS}
N 610 -3580 630 -3580 {
lab=Y0}
N 610 -3560 630 -3560 {
lab=Y1}
N 610 -3540 630 -3540 {
lab=Y2}
N 610 -3520 630 -3520 {
lab=Y3}
N 610 -3500 630 -3500 {
lab=Y4}
N 610 -3480 630 -3480 {
lab=Y5}
N 610 -3460 630 -3460 {
lab=Y6}
N 610 -3440 630 -3440 {
lab=Y7}
N 610 -3330 630 -3330 {
lab=Y8}
N 610 -3310 630 -3310 {
lab=Y9}
N 610 -3290 630 -3290 {
lab=Y10}
N 610 -3270 630 -3270 {
lab=Y11}
N 610 -3250 630 -3250 {
lab=Y12}
N 610 -3230 630 -3230 {
lab=Y13}
N 610 -3210 630 -3210 {
lab=Y14}
N 610 -3190 630 -3190 {
lab=Y15}
N 610 -3080 630 -3080 {
lab=Y16}
N 610 -3060 630 -3060 {
lab=Y17}
N 610 -3040 630 -3040 {
lab=Y18}
N 610 -3020 630 -3020 {
lab=Y19}
N 610 -3000 630 -3000 {
lab=Y20}
N 610 -2980 630 -2980 {
lab=Y21}
N 610 -2960 630 -2960 {
lab=Y22}
N 610 -2940 630 -2940 {
lab=Y23}
N 610 -2820 630 -2820 {
lab=Y24}
N 610 -2800 630 -2800 {
lab=Y25}
N 610 -2780 630 -2780 {
lab=Y26}
N 610 -2760 630 -2760 {
lab=Y27}
N 610 -2740 630 -2740 {
lab=Y28}
N 610 -2720 630 -2720 {
lab=Y29}
N 610 -2700 630 -2700 {
lab=Y30}
N 610 -2680 630 -2680 {
lab=Y31}
N 320 -2470 340 -2470 {
lab=SEL[0]}
N 10 -2470 20 -2470 {
lab=Y0}
N 520 -2470 540 -2470 {
lab=#net6}
N 440 -2510 600 -2510 {
lab=VDD}
N 440 -2430 600 -2430 {
lab=VSS}
N 680 -2470 700 -2470 {
lab=SEL1}
N 370 -2470 380 -2470 {
lab=Y1}
N 900 -2470 920 -2470 {
lab=#net7}
N 820 -2510 980 -2510 {
lab=VDD}
N 820 -2430 980 -2430 {
lab=VSS}
N 1060 -2470 1080 -2470 {
lab=SEL[2]}
N 750 -2470 760 -2470 {
lab=Y2}
N 1260 -2470 1280 -2470 {
lab=#net8}
N 1180 -2510 1340 -2510 {
lab=VDD}
N 1180 -2430 1340 -2430 {
lab=VSS}
N 1420 -2470 1440 -2470 {
lab=SEL[3]}
N 1110 -2470 1120 -2470 {
lab=Y3}
N 160 -2300 180 -2300 {
lab=#net9}
N 80 -2340 240 -2340 {
lab=VDD}
N 80 -2260 240 -2260 {
lab=VSS}
N 320 -2300 340 -2300 {
lab=SEL[4]}
N 10 -2300 20 -2300 {
lab=Y4}
N 520 -2300 540 -2300 {
lab=#net10}
N 440 -2340 600 -2340 {
lab=VDD}
N 440 -2260 600 -2260 {
lab=VSS}
N 680 -2300 700 -2300 {
lab=SEL[5]}
N 370 -2300 380 -2300 {
lab=Y5}
N 900 -2300 920 -2300 {
lab=#net11}
N 820 -2340 980 -2340 {
lab=VDD}
N 820 -2260 980 -2260 {
lab=VSS}
N 1060 -2300 1080 -2300 {
lab=SEL[6]}
N 750 -2300 760 -2300 {
lab=Y6}
N 1260 -2300 1280 -2300 {
lab=#net12}
N 1180 -2340 1340 -2340 {
lab=VDD}
N 1180 -2260 1340 -2260 {
lab=VSS}
N 1420 -2300 1440 -2300 {
lab=SEL[7]}
N 1110 -2300 1120 -2300 {
lab=Y7}
N 150 -2130 170 -2130 {
lab=#net13}
N 70 -2170 230 -2170 {
lab=VDD}
N 70 -2090 230 -2090 {
lab=VSS}
N 310 -2130 330 -2130 {
lab=SEL[8]}
N 0 -2130 10 -2130 {
lab=Y8}
N 510 -2130 530 -2130 {
lab=#net14}
N 430 -2170 590 -2170 {
lab=VDD}
N 430 -2090 590 -2090 {
lab=VSS}
N 670 -2130 690 -2130 {
lab=SEL[9]}
N 360 -2130 370 -2130 {
lab=Y9}
N 890 -2130 910 -2130 {
lab=#net15}
N 810 -2170 970 -2170 {
lab=VDD}
N 810 -2090 970 -2090 {
lab=VSS}
N 1050 -2130 1070 -2130 {
lab=SEL[10]}
N 740 -2130 750 -2130 {
lab=Y10}
N 1250 -2130 1270 -2130 {
lab=#net16}
N 1170 -2170 1330 -2170 {
lab=VDD}
N 1170 -2090 1330 -2090 {
lab=VSS}
N 1410 -2130 1430 -2130 {
lab=SEL[11]}
N 1100 -2130 1110 -2130 {
lab=Y11}
N 150 -1960 170 -1960 {
lab=#net17}
N 70 -2000 230 -2000 {
lab=VDD}
N 70 -1920 230 -1920 {
lab=VSS}
N 310 -1960 330 -1960 {
lab=SEL[12]}
N 0 -1960 10 -1960 {
lab=Y12}
N 510 -1960 530 -1960 {
lab=#net18}
N 430 -2000 590 -2000 {
lab=VDD}
N 430 -1920 590 -1920 {
lab=VSS}
N 670 -1960 690 -1960 {
lab=SEL[13]}
N 360 -1960 370 -1960 {
lab=Y13}
N 890 -1960 910 -1960 {
lab=#net19}
N 810 -2000 970 -2000 {
lab=VDD}
N 810 -1920 970 -1920 {
lab=VSS}
N 1050 -1960 1070 -1960 {
lab=SEL[14]}
N 740 -1960 750 -1960 {
lab=Y14}
N 1250 -1960 1270 -1960 {
lab=#net20}
N 1170 -2000 1330 -2000 {
lab=VDD}
N 1170 -1920 1330 -1920 {
lab=VSS}
N 1410 -1960 1430 -1960 {
lab=SEL[15]}
N 1100 -1960 1110 -1960 {
lab=Y15}
N 160 -1790 180 -1790 {
lab=#net21}
N 80 -1830 240 -1830 {
lab=VDD}
N 80 -1750 240 -1750 {
lab=VSS}
N 320 -1790 340 -1790 {
lab=SEL[16]}
N 10 -1790 20 -1790 {
lab=Y16}
N 520 -1790 540 -1790 {
lab=#net22}
N 440 -1830 600 -1830 {
lab=VDD}
N 440 -1750 600 -1750 {
lab=VSS}
N 680 -1790 700 -1790 {
lab=SEL[17]}
N 370 -1790 380 -1790 {
lab=Y17}
N 900 -1790 920 -1790 {
lab=#net23}
N 820 -1830 980 -1830 {
lab=VDD}
N 820 -1750 980 -1750 {
lab=VSS}
N 1060 -1790 1080 -1790 {
lab=SEL[18]}
N 750 -1790 760 -1790 {
lab=Y18}
N 1260 -1790 1280 -1790 {
lab=#net24}
N 1180 -1830 1340 -1830 {
lab=VDD}
N 1180 -1750 1340 -1750 {
lab=VSS}
N 1420 -1790 1440 -1790 {
lab=SEL[19]}
N 1110 -1790 1120 -1790 {
lab=Y19}
N 160 -1620 180 -1620 {
lab=#net25}
N 80 -1660 240 -1660 {
lab=VDD}
N 80 -1580 240 -1580 {
lab=VSS}
N 320 -1620 340 -1620 {
lab=SEL[20]}
N 10 -1620 20 -1620 {
lab=Y20}
N 520 -1620 540 -1620 {
lab=#net26}
N 440 -1660 600 -1660 {
lab=VDD}
N 440 -1580 600 -1580 {
lab=VSS}
N 680 -1620 700 -1620 {
lab=SEL[21]}
N 370 -1620 380 -1620 {
lab=Y21}
N 900 -1620 920 -1620 {
lab=#net27}
N 820 -1660 980 -1660 {
lab=VDD}
N 820 -1580 980 -1580 {
lab=VSS}
N 1060 -1620 1080 -1620 {
lab=SEL[22]}
N 750 -1620 760 -1620 {
lab=Y22}
N 1260 -1620 1280 -1620 {
lab=#net28}
N 1180 -1660 1340 -1660 {
lab=VDD}
N 1180 -1580 1340 -1580 {
lab=VSS}
N 1420 -1620 1440 -1620 {
lab=SEL[23]}
N 1110 -1620 1120 -1620 {
lab=Y23}
N 160 -1450 180 -1450 {
lab=#net29}
N 80 -1490 240 -1490 {
lab=VDD}
N 80 -1410 240 -1410 {
lab=VSS}
N 320 -1450 340 -1450 {
lab=SEL[24]}
N 10 -1450 20 -1450 {
lab=Y24}
N 520 -1450 540 -1450 {
lab=#net30}
N 440 -1490 600 -1490 {
lab=VDD}
N 440 -1410 600 -1410 {
lab=VSS}
N 680 -1450 700 -1450 {
lab=SEL[25]}
N 370 -1450 380 -1450 {
lab=Y25}
N 900 -1450 920 -1450 {
lab=#net31}
N 820 -1490 980 -1490 {
lab=VDD}
N 820 -1410 980 -1410 {
lab=VSS}
N 1060 -1450 1080 -1450 {
lab=SEL[26]}
N 750 -1450 760 -1450 {
lab=Y26}
N 1260 -1450 1280 -1450 {
lab=#net32}
N 1180 -1490 1340 -1490 {
lab=VDD}
N 1180 -1410 1340 -1410 {
lab=VSS}
N 1420 -1450 1440 -1450 {
lab=SEL[27]}
N 1110 -1450 1120 -1450 {
lab=Y27}
N 160 -1280 180 -1280 {
lab=#net33}
N 80 -1320 240 -1320 {
lab=VDD}
N 80 -1240 240 -1240 {
lab=VSS}
N 320 -1280 340 -1280 {
lab=SEL[28]}
N 10 -1280 20 -1280 {
lab=Y28}
N 520 -1280 540 -1280 {
lab=#net34}
N 440 -1320 600 -1320 {
lab=VDD}
N 440 -1240 600 -1240 {
lab=VSS}
N 680 -1280 700 -1280 {
lab=SEL[29]}
N 370 -1280 380 -1280 {
lab=Y29}
N 900 -1280 920 -1280 {
lab=#net35}
N 820 -1320 980 -1320 {
lab=VDD}
N 820 -1240 980 -1240 {
lab=VSS}
N 1060 -1280 1080 -1280 {
lab=SEL[30]}
N 750 -1280 760 -1280 {
lab=Y30}
N 1260 -1280 1280 -1280 {
lab=#net36}
N 1180 -1320 1340 -1320 {
lab=VDD}
N 1180 -1240 1340 -1240 {
lab=VSS}
N 1420 -1280 1440 -1280 {
lab=SEL[31]}
N 1110 -1280 1120 -1280 {
lab=Y31}
N 150 -3820 170 -3820 {
lab=#net37}
N 170 -3820 190 -3820 {
lab=#net37}
N 0 -3820 10 -3820 {
lab=#net38}
N 980 -2930 1000 -2930 {
lab=#net39}
N 900 -2970 1060 -2970 {
lab=VDD}
N 900 -2890 1060 -2890 {
lab=VSS}
N 1140 -2930 1160 -2930 {
lab=we3_buf}
N 830 -2930 840 -2930 {
lab=WE3}
N 980 -3050 1000 -3050 {
lab=#net40}
N 900 -3090 1060 -3090 {
lab=VDD}
N 900 -3010 1060 -3010 {
lab=VSS}
N 1140 -3050 1160 -3050 {
lab=we2_buf}
N 830 -3050 840 -3050 {
lab=WE2}
N 980 -3180 1000 -3180 {
lab=#net41}
N 900 -3220 1060 -3220 {
lab=VDD}
N 900 -3140 1060 -3140 {
lab=VSS}
N 1140 -3180 1160 -3180 {
lab=we1_buf}
N 830 -3180 840 -3180 {
lab=WE1}
N 980 -3300 1000 -3300 {
lab=#net42}
N 900 -3340 1060 -3340 {
lab=VDD}
N 900 -3260 1060 -3260 {
lab=VSS}
N 1140 -3300 1160 -3300 {
lab=we0_buf}
N 830 -3300 840 -3300 {
lab=WE0}
N 160 -990 180 -990 {
lab=#net43}
N 80 -1030 240 -1030 {
lab=VDD}
N 80 -950 240 -950 {
lab=VSS}
N 320 -990 340 -990 {
lab=di0_buf}
N -10 -990 0 -990 {
lab=Di0}
N 720 -990 740 -990 {
lab=di1_buf}
N 160 -860 180 -860 {
lab=#net44}
N 80 -900 240 -900 {
lab=VDD}
N 80 -820 240 -820 {
lab=VSS}
N 320 -860 340 -860 {
lab=di4_buf}
N -10 -860 0 -860 {
lab=Di4}
N 1520 -990 1540 -990 {
lab=di3_buf}
N 1520 -860 1540 -860 {
lab=di7_buf}
N 1120 -860 1140 -860 {
lab=di6_buf}
N 1120 -990 1140 -990 {
lab=di2_buf}
N 1520 -990 1540 -990 {
lab=di3_buf}
N 1520 -860 1540 -860 {
lab=di7_buf}
N 720 -860 740 -860 {
lab=di5_buf}
N 160 -730 180 -730 {
lab=#net45}
N 80 -770 240 -770 {
lab=VDD}
N 80 -690 240 -690 {
lab=VSS}
N 320 -730 340 -730 {
lab=di8_buf}
N -10 -730 0 -730 {
lab=Di8}
N 720 -730 740 -730 {
lab=di9_buf}
N 1120 -730 1140 -730 {
lab=di10_buf}
N 1520 -730 1540 -730 {
lab=di11_buf}
N 1520 -600 1540 -600 {
lab=di15_buf}
N 1120 -600 1140 -600 {
lab=di14_buf}
N 720 -600 740 -600 {
lab=di13_buf}
N 160 -600 180 -600 {
lab=#net46}
N 80 -640 240 -640 {
lab=VDD}
N 80 -560 240 -560 {
lab=VSS}
N 320 -600 340 -600 {
lab=di12_buf}
N -10 -600 0 -600 {
lab=Di12}
N 160 -470 180 -470 {
lab=#net47}
N 80 -510 240 -510 {
lab=VDD}
N 80 -430 240 -430 {
lab=VSS}
N 320 -470 340 -470 {
lab=di16_buf}
N -10 -470 0 -470 {
lab=Di16}
N 160 -340 180 -340 {
lab=#net48}
N 80 -380 240 -380 {
lab=VDD}
N 80 -300 240 -300 {
lab=VSS}
N 320 -340 340 -340 {
lab=Di[20]}
N -10 -340 0 -340 {
lab=Di20}
N 160 -210 180 -210 {
lab=#net49}
N 80 -250 240 -250 {
lab=VDD}
N 80 -170 240 -170 {
lab=VSS}
N 320 -210 340 -210 {
lab=Di[24]}
N -10 -210 0 -210 {
lab=Di24}
N 160 -80 180 -80 {
lab=#net50}
N 80 -120 240 -120 {
lab=VDD}
N 80 -40 240 -40 {
lab=VSS}
N 320 -80 340 -80 {
lab=Di[28]}
N -10 -80 0 -80 {
lab=Di28}
N 720 -80 740 -80 {
lab=Di[29]}
N 720 -210 740 -210 {
lab=Di[25]}
N 720 -340 740 -340 {
lab=Di[21]}
N 720 -470 740 -470 {
lab=Di[17]}
N 1120 -470 1140 -470 {
lab=Di[18]}
N 1120 -340 1140 -340 {
lab=Di[22]}
N 1120 -210 1140 -210 {
lab=Di[26]}
N 1120 -80 1140 -80 {
lab=Di[30]}
N 1520 -80 1540 -80 {
lab=Di[31]}
N 1520 -210 1540 -210 {
lab=Di[27]}
N 1520 -340 1540 -340 {
lab=Di[23]}
N 1520 -470 1540 -470 {
lab=Di[19]}
N 1740 -3590 1760 -3590 {
lab=di0_buf}
N 1740 -3570 1760 -3570 {
lab=di1_buf}
N 1740 -3550 1760 -3550 {
lab=di2_buf}
N 1740 -3530 1760 -3530 {
lab=di3_buf}
N 1740 -3510 1760 -3510 {
lab=di4_buf}
N 1740 -3490 1760 -3490 {
lab=di5_buf}
N 1740 -3470 1760 -3470 {
lab=di6_buf}
N 1740 -3450 1760 -3450 {
lab=di7_buf}
N 1740 -3430 1760 -3430 {
lab=di8_buf}
N 1740 -3410 1760 -3410 {
lab=di9_buf}
N 1740 -3390 1760 -3390 {
lab=di10_buf}
N 1740 -3370 1760 -3370 {
lab=di11_buf}
N 1740 -3350 1760 -3350 {
lab=di12_buf}
N 1740 -3330 1760 -3330 {
lab=di13_buf}
N 1740 -3310 1760 -3310 {
lab=di14_buf}
N 1740 -3290 1760 -3290 {
lab=di15_buf}
N 1740 -3270 1760 -3270 {
lab=di16_buf}
N 1740 -3250 1760 -3250 {
lab=Di[17]}
N 1740 -3230 1760 -3230 {
lab=Di[18]}
N 1740 -3210 1760 -3210 {
lab=Di[19]}
N 1740 -3190 1760 -3190 {
lab=Di[20]}
N 1740 -3170 1760 -3170 {
lab=Di[21]}
N 1740 -3150 1760 -3150 {
lab=Di[22]}
N 1740 -3130 1760 -3130 {
lab=Di[23]}
N 1740 -3110 1760 -3110 {
lab=Di[24]}
N 1740 -3090 1760 -3090 {
lab=Di[25]}
N 1740 -3070 1760 -3070 {
lab=Di[26]}
N 1740 -3050 1760 -3050 {
lab=Di[27]}
N 1740 -3030 1760 -3030 {
lab=Di[28]}
N 1740 -3010 1760 -3010 {
lab=Di[29]}
N 1740 -2990 1760 -2990 {
lab=Di[30]}
N 1740 -2970 1760 -2970 {
lab=Di[31]}
N 2060 -3590 2080 -3590 {
lab=Do0}
N 2060 -3570 2080 -3570 {
lab=Do1}
N 2060 -3550 2080 -3550 {
lab=Do2}
N 2060 -3530 2080 -3530 {
lab=Do3}
N 2060 -3510 2080 -3510 {
lab=Do4}
N 2060 -3490 2080 -3490 {
lab=Do5}
N 2060 -3470 2080 -3470 {
lab=Do6}
N 2060 -3450 2080 -3450 {
lab=Do7}
N 2060 -3430 2080 -3430 {
lab=Do8}
N 2060 -3410 2080 -3410 {
lab=Do9}
N 2060 -3390 2080 -3390 {
lab=Do10}
N 2060 -3370 2080 -3370 {
lab=Do11}
N 2060 -3350 2080 -3350 {
lab=Do12}
N 2060 -3330 2080 -3330 {
lab=Do13}
N 2060 -3310 2080 -3310 {
lab=Do14}
N 2060 -3290 2080 -3290 {
lab=Do15}
N 2060 -3270 2080 -3270 {
lab=Do16}
N 2060 -3250 2080 -3250 {
lab=Do17}
N 2060 -3230 2080 -3230 {
lab=Do18}
N 2060 -3210 2080 -3210 {
lab=Do19}
N 2060 -3190 2080 -3190 {
lab=Do20}
N 2060 -3170 2080 -3170 {
lab=Do21}
N 2060 -3150 2080 -3150 {
lab=Do22}
N 2060 -3130 2080 -3130 {
lab=Do23}
N 2060 -3110 2080 -3110 {
lab=Do24}
N 2060 -3090 2080 -3090 {
lab=Do25}
N 2060 -3070 2080 -3070 {
lab=Do26}
N 2060 -3050 2080 -3050 {
lab=Do27}
N 2060 -3030 2080 -3030 {
lab=Do28}
N 2060 -3010 2080 -3010 {
lab=Do29}
N 2060 -2990 2080 -2990 {
lab=Do30}
N 2060 -2970 2080 -2970 {
lab=Do31}
N 1830 -3650 1830 -3630 {
lab=CLK_buf}
N 1850 -3650 1850 -3630 {
lab=SEL[0]}
N 1870 -3650 1870 -3630 {
lab=we0_buf}
N 1890 -3650 1890 -3630 {
lab=we1_buf}
N 1910 -3650 1910 -3630 {
lab=we2_buf}
N 1930 -3650 1930 -3630 {
lab=we3_buf}
N 1960 -3650 1960 -3630 {
lab=VDD}
N 1980 -3650 1980 -3630 {
lab=VSS}
N 2260 -3590 2280 -3590 {
lab=di0_buf}
N 2260 -3570 2280 -3570 {
lab=di1_buf}
N 2260 -3550 2280 -3550 {
lab=di2_buf}
N 2260 -3530 2280 -3530 {
lab=di3_buf}
N 2260 -3510 2280 -3510 {
lab=di4_buf}
N 2260 -3490 2280 -3490 {
lab=di5_buf}
N 2260 -3470 2280 -3470 {
lab=di6_buf}
N 2260 -3450 2280 -3450 {
lab=di7_buf}
N 2260 -3430 2280 -3430 {
lab=di8_buf}
N 2260 -3410 2280 -3410 {
lab=di9_buf}
N 2260 -3390 2280 -3390 {
lab=di10_buf}
N 2260 -3370 2280 -3370 {
lab=di11_buf}
N 2260 -3350 2280 -3350 {
lab=di12_buf}
N 2260 -3330 2280 -3330 {
lab=di13_buf}
N 2260 -3310 2280 -3310 {
lab=di14_buf}
N 2260 -3290 2280 -3290 {
lab=di15_buf}
N 2260 -3270 2280 -3270 {
lab=di16_buf}
N 2260 -3250 2280 -3250 {
lab=Di[17]}
N 2260 -3230 2280 -3230 {
lab=Di[18]}
N 2260 -3210 2280 -3210 {
lab=Di[19]}
N 2260 -3190 2280 -3190 {
lab=Di[20]}
N 2260 -3170 2280 -3170 {
lab=Di[21]}
N 2260 -3150 2280 -3150 {
lab=Di[22]}
N 2260 -3130 2280 -3130 {
lab=Di[23]}
N 2260 -3110 2280 -3110 {
lab=Di[24]}
N 2260 -3090 2280 -3090 {
lab=Di[25]}
N 2260 -3070 2280 -3070 {
lab=Di[26]}
N 2260 -3050 2280 -3050 {
lab=Di[27]}
N 2260 -3030 2280 -3030 {
lab=Di[28]}
N 2260 -3010 2280 -3010 {
lab=Di[29]}
N 2260 -2990 2280 -2990 {
lab=Di[30]}
N 2260 -2970 2280 -2970 {
lab=Di[31]}
N 2350 -3650 2350 -3630 {
lab=CLK_buf}
N 2370 -3650 2370 -3630 {
lab=SEL1}
N 2390 -3650 2390 -3630 {
lab=we0_buf}
N 2410 -3650 2410 -3630 {
lab=we1_buf}
N 2430 -3650 2430 -3630 {
lab=we2_buf}
N 2450 -3650 2450 -3630 {
lab=we3_buf}
N 2480 -3650 2480 -3630 {
lab=VDD}
N 2500 -3650 2500 -3630 {
lab=VSS}
N 2800 -3590 2820 -3590 {
lab=di0_buf}
N 2800 -3570 2820 -3570 {
lab=di1_buf}
N 2800 -3550 2820 -3550 {
lab=di2_buf}
N 2800 -3530 2820 -3530 {
lab=di3_buf}
N 2800 -3510 2820 -3510 {
lab=di4_buf}
N 2800 -3490 2820 -3490 {
lab=di5_buf}
N 2800 -3470 2820 -3470 {
lab=di6_buf}
N 2800 -3450 2820 -3450 {
lab=di7_buf}
N 2800 -3430 2820 -3430 {
lab=di8_buf}
N 2800 -3410 2820 -3410 {
lab=di9_buf}
N 2800 -3390 2820 -3390 {
lab=di10_buf}
N 2800 -3370 2820 -3370 {
lab=di11_buf}
N 2800 -3350 2820 -3350 {
lab=di12_buf}
N 2800 -3330 2820 -3330 {
lab=di13_buf}
N 2800 -3310 2820 -3310 {
lab=di14_buf}
N 2800 -3290 2820 -3290 {
lab=di15_buf}
N 2800 -3270 2820 -3270 {
lab=di16_buf}
N 2800 -3250 2820 -3250 {
lab=Di[17]}
N 2800 -3230 2820 -3230 {
lab=Di[18]}
N 2800 -3210 2820 -3210 {
lab=Di[19]}
N 2800 -3190 2820 -3190 {
lab=Di[20]}
N 2800 -3170 2820 -3170 {
lab=Di[21]}
N 2800 -3150 2820 -3150 {
lab=Di[22]}
N 2800 -3130 2820 -3130 {
lab=Di[23]}
N 2800 -3110 2820 -3110 {
lab=Di[24]}
N 2800 -3090 2820 -3090 {
lab=Di[25]}
N 2800 -3070 2820 -3070 {
lab=Di[26]}
N 2800 -3050 2820 -3050 {
lab=Di[27]}
N 2800 -3030 2820 -3030 {
lab=Di[28]}
N 2800 -3010 2820 -3010 {
lab=Di[29]}
N 2800 -2990 2820 -2990 {
lab=Di[30]}
N 2800 -2970 2820 -2970 {
lab=Di[31]}
N 2890 -3650 2890 -3630 {
lab=CLK_buf}
N 2910 -3650 2910 -3630 {
lab=SEL[2]}
N 2930 -3650 2930 -3630 {
lab=we0_buf}
N 2950 -3650 2950 -3630 {
lab=we1_buf}
N 2970 -3650 2970 -3630 {
lab=we2_buf}
N 2990 -3650 2990 -3630 {
lab=we3_buf}
N 3020 -3650 3020 -3630 {
lab=VDD}
N 3040 -3650 3040 -3630 {
lab=VSS}
N 3320 -3590 3340 -3590 {
lab=di0_buf}
N 3320 -3570 3340 -3570 {
lab=di1_buf}
N 3320 -3550 3340 -3550 {
lab=di2_buf}
N 3320 -3530 3340 -3530 {
lab=di3_buf}
N 3320 -3510 3340 -3510 {
lab=di4_buf}
N 3320 -3490 3340 -3490 {
lab=di5_buf}
N 3320 -3470 3340 -3470 {
lab=di6_buf}
N 3320 -3450 3340 -3450 {
lab=di7_buf}
N 3320 -3430 3340 -3430 {
lab=di8_buf}
N 3320 -3410 3340 -3410 {
lab=di9_buf}
N 3320 -3390 3340 -3390 {
lab=di10_buf}
N 3320 -3370 3340 -3370 {
lab=di11_buf}
N 3320 -3350 3340 -3350 {
lab=di12_buf}
N 3320 -3330 3340 -3330 {
lab=di13_buf}
N 3320 -3310 3340 -3310 {
lab=di14_buf}
N 3320 -3290 3340 -3290 {
lab=di15_buf}
N 3320 -3270 3340 -3270 {
lab=di16_buf}
N 3320 -3250 3340 -3250 {
lab=Di[17]}
N 3320 -3230 3340 -3230 {
lab=Di[18]}
N 3320 -3210 3340 -3210 {
lab=Di[19]}
N 3320 -3190 3340 -3190 {
lab=Di[20]}
N 3320 -3170 3340 -3170 {
lab=Di[21]}
N 3320 -3150 3340 -3150 {
lab=Di[22]}
N 3320 -3130 3340 -3130 {
lab=Di[23]}
N 3320 -3110 3340 -3110 {
lab=Di[24]}
N 3320 -3090 3340 -3090 {
lab=Di[25]}
N 3320 -3070 3340 -3070 {
lab=Di[26]}
N 3320 -3050 3340 -3050 {
lab=Di[27]}
N 3320 -3030 3340 -3030 {
lab=Di[28]}
N 3320 -3010 3340 -3010 {
lab=Di[29]}
N 3320 -2990 3340 -2990 {
lab=Di[30]}
N 3320 -2970 3340 -2970 {
lab=Di[31]}
N 3410 -3650 3410 -3630 {
lab=CLK_buf}
N 3430 -3650 3430 -3630 {
lab=SEL[3]}
N 3450 -3650 3450 -3630 {
lab=we0_buf}
N 3470 -3650 3470 -3630 {
lab=we1_buf}
N 3490 -3650 3490 -3630 {
lab=we2_buf}
N 3510 -3650 3510 -3630 {
lab=we3_buf}
N 3540 -3650 3540 -3630 {
lab=VDD}
N 3560 -3650 3560 -3630 {
lab=VSS}
N 3840 -3590 3860 -3590 {
lab=di0_buf}
N 3840 -3570 3860 -3570 {
lab=di1_buf}
N 3840 -3550 3860 -3550 {
lab=di2_buf}
N 3840 -3530 3860 -3530 {
lab=di3_buf}
N 3840 -3510 3860 -3510 {
lab=di4_buf}
N 3840 -3490 3860 -3490 {
lab=di5_buf}
N 3840 -3470 3860 -3470 {
lab=di6_buf}
N 3840 -3450 3860 -3450 {
lab=di7_buf}
N 3840 -3430 3860 -3430 {
lab=di8_buf}
N 3840 -3410 3860 -3410 {
lab=di9_buf}
N 3840 -3390 3860 -3390 {
lab=di10_buf}
N 3840 -3370 3860 -3370 {
lab=di11_buf}
N 3840 -3350 3860 -3350 {
lab=di12_buf}
N 3840 -3330 3860 -3330 {
lab=di13_buf}
N 3840 -3310 3860 -3310 {
lab=di14_buf}
N 3840 -3290 3860 -3290 {
lab=di15_buf}
N 3840 -3270 3860 -3270 {
lab=di16_buf}
N 3840 -3250 3860 -3250 {
lab=Di[17]}
N 3840 -3230 3860 -3230 {
lab=Di[18]}
N 3840 -3210 3860 -3210 {
lab=Di[19]}
N 3840 -3190 3860 -3190 {
lab=Di[20]}
N 3840 -3170 3860 -3170 {
lab=Di[21]}
N 3840 -3150 3860 -3150 {
lab=Di[22]}
N 3840 -3130 3860 -3130 {
lab=Di[23]}
N 3840 -3110 3860 -3110 {
lab=Di[24]}
N 3840 -3090 3860 -3090 {
lab=Di[25]}
N 3840 -3070 3860 -3070 {
lab=Di[26]}
N 3840 -3050 3860 -3050 {
lab=Di[27]}
N 3840 -3030 3860 -3030 {
lab=Di[28]}
N 3840 -3010 3860 -3010 {
lab=Di[29]}
N 3840 -2990 3860 -2990 {
lab=Di[30]}
N 3840 -2970 3860 -2970 {
lab=Di[31]}
N 3930 -3650 3930 -3630 {
lab=CLK_buf}
N 3950 -3650 3950 -3630 {
lab=SEL[4]}
N 3970 -3650 3970 -3630 {
lab=we0_buf}
N 3990 -3650 3990 -3630 {
lab=we1_buf}
N 4010 -3650 4010 -3630 {
lab=we2_buf}
N 4030 -3650 4030 -3630 {
lab=we3_buf}
N 4060 -3650 4060 -3630 {
lab=VDD}
N 4080 -3650 4080 -3630 {
lab=VSS}
N 4360 -3590 4380 -3590 {
lab=di0_buf}
N 4360 -3570 4380 -3570 {
lab=di1_buf}
N 4360 -3550 4380 -3550 {
lab=di2_buf}
N 4360 -3530 4380 -3530 {
lab=di3_buf}
N 4360 -3510 4380 -3510 {
lab=di4_buf}
N 4360 -3490 4380 -3490 {
lab=di5_buf}
N 4360 -3470 4380 -3470 {
lab=di6_buf}
N 4360 -3450 4380 -3450 {
lab=di7_buf}
N 4360 -3430 4380 -3430 {
lab=di8_buf}
N 4360 -3410 4380 -3410 {
lab=di9_buf}
N 4360 -3390 4380 -3390 {
lab=di10_buf}
N 4360 -3370 4380 -3370 {
lab=di11_buf}
N 4360 -3350 4380 -3350 {
lab=di12_buf}
N 4360 -3330 4380 -3330 {
lab=di13_buf}
N 4360 -3310 4380 -3310 {
lab=di14_buf}
N 4360 -3290 4380 -3290 {
lab=di15_buf}
N 4360 -3270 4380 -3270 {
lab=di16_buf}
N 4360 -3250 4380 -3250 {
lab=Di[17]}
N 4360 -3230 4380 -3230 {
lab=Di[18]}
N 4360 -3210 4380 -3210 {
lab=Di[19]}
N 4360 -3190 4380 -3190 {
lab=Di[20]}
N 4360 -3170 4380 -3170 {
lab=Di[21]}
N 4360 -3150 4380 -3150 {
lab=Di[22]}
N 4360 -3130 4380 -3130 {
lab=Di[23]}
N 4360 -3110 4380 -3110 {
lab=Di[24]}
N 4360 -3090 4380 -3090 {
lab=Di[25]}
N 4360 -3070 4380 -3070 {
lab=Di[26]}
N 4360 -3050 4380 -3050 {
lab=Di[27]}
N 4360 -3030 4380 -3030 {
lab=Di[28]}
N 4360 -3010 4380 -3010 {
lab=Di[29]}
N 4360 -2990 4380 -2990 {
lab=Di[30]}
N 4360 -2970 4380 -2970 {
lab=Di[31]}
N 4450 -3650 4450 -3630 {
lab=CLK_buf}
N 4470 -3650 4470 -3630 {
lab=SEL[5]}
N 4490 -3650 4490 -3630 {
lab=we0_buf}
N 4510 -3650 4510 -3630 {
lab=we1_buf}
N 4530 -3650 4530 -3630 {
lab=we2_buf}
N 4550 -3650 4550 -3630 {
lab=we3_buf}
N 4580 -3650 4580 -3630 {
lab=VDD}
N 4600 -3650 4600 -3630 {
lab=VSS}
N 4900 -3590 4920 -3590 {
lab=di0_buf}
N 4900 -3570 4920 -3570 {
lab=di1_buf}
N 4900 -3550 4920 -3550 {
lab=di2_buf}
N 4900 -3530 4920 -3530 {
lab=di3_buf}
N 4900 -3510 4920 -3510 {
lab=di4_buf}
N 4900 -3490 4920 -3490 {
lab=di5_buf}
N 4900 -3470 4920 -3470 {
lab=di6_buf}
N 4900 -3450 4920 -3450 {
lab=di7_buf}
N 4900 -3430 4920 -3430 {
lab=di8_buf}
N 4900 -3410 4920 -3410 {
lab=di9_buf}
N 4900 -3390 4920 -3390 {
lab=di10_buf}
N 4900 -3370 4920 -3370 {
lab=di11_buf}
N 4900 -3350 4920 -3350 {
lab=di12_buf}
N 4900 -3330 4920 -3330 {
lab=di13_buf}
N 4900 -3310 4920 -3310 {
lab=di14_buf}
N 4900 -3290 4920 -3290 {
lab=di15_buf}
N 4900 -3270 4920 -3270 {
lab=di16_buf}
N 4900 -3250 4920 -3250 {
lab=Di[17]}
N 4900 -3230 4920 -3230 {
lab=Di[18]}
N 4900 -3210 4920 -3210 {
lab=Di[19]}
N 4900 -3190 4920 -3190 {
lab=Di[20]}
N 4900 -3170 4920 -3170 {
lab=Di[21]}
N 4900 -3150 4920 -3150 {
lab=Di[22]}
N 4900 -3130 4920 -3130 {
lab=Di[23]}
N 4900 -3110 4920 -3110 {
lab=Di[24]}
N 4900 -3090 4920 -3090 {
lab=Di[25]}
N 4900 -3070 4920 -3070 {
lab=Di[26]}
N 4900 -3050 4920 -3050 {
lab=Di[27]}
N 4900 -3030 4920 -3030 {
lab=Di[28]}
N 4900 -3010 4920 -3010 {
lab=Di[29]}
N 4900 -2990 4920 -2990 {
lab=Di[30]}
N 4900 -2970 4920 -2970 {
lab=Di[31]}
N 4990 -3650 4990 -3630 {
lab=CLK_buf}
N 5010 -3650 5010 -3630 {
lab=SEL[6]}
N 5030 -3650 5030 -3630 {
lab=we0_buf}
N 5050 -3650 5050 -3630 {
lab=we1_buf}
N 5070 -3650 5070 -3630 {
lab=we2_buf}
N 5090 -3650 5090 -3630 {
lab=we3_buf}
N 5120 -3650 5120 -3630 {
lab=VDD}
N 5140 -3650 5140 -3630 {
lab=VSS}
N 5420 -3590 5440 -3590 {
lab=di0_buf}
N 5420 -3570 5440 -3570 {
lab=di1_buf}
N 5420 -3550 5440 -3550 {
lab=di2_buf}
N 5420 -3530 5440 -3530 {
lab=di3_buf}
N 5420 -3510 5440 -3510 {
lab=di4_buf}
N 5420 -3490 5440 -3490 {
lab=di5_buf}
N 5420 -3470 5440 -3470 {
lab=di6_buf}
N 5420 -3450 5440 -3450 {
lab=di7_buf}
N 5420 -3430 5440 -3430 {
lab=di8_buf}
N 5420 -3410 5440 -3410 {
lab=di9_buf}
N 5420 -3390 5440 -3390 {
lab=di10_buf}
N 5420 -3370 5440 -3370 {
lab=di11_buf}
N 5420 -3350 5440 -3350 {
lab=di12_buf}
N 5420 -3330 5440 -3330 {
lab=di13_buf}
N 5420 -3310 5440 -3310 {
lab=di14_buf}
N 5420 -3290 5440 -3290 {
lab=di15_buf}
N 5420 -3270 5440 -3270 {
lab=di16_buf}
N 5420 -3250 5440 -3250 {
lab=Di[17]}
N 5420 -3230 5440 -3230 {
lab=Di[18]}
N 5420 -3210 5440 -3210 {
lab=Di[19]}
N 5420 -3190 5440 -3190 {
lab=Di[20]}
N 5420 -3170 5440 -3170 {
lab=Di[21]}
N 5420 -3150 5440 -3150 {
lab=Di[22]}
N 5420 -3130 5440 -3130 {
lab=Di[23]}
N 5420 -3110 5440 -3110 {
lab=Di[24]}
N 5420 -3090 5440 -3090 {
lab=Di[25]}
N 5420 -3070 5440 -3070 {
lab=Di[26]}
N 5420 -3050 5440 -3050 {
lab=Di[27]}
N 5420 -3030 5440 -3030 {
lab=Di[28]}
N 5420 -3010 5440 -3010 {
lab=Di[29]}
N 5420 -2990 5440 -2990 {
lab=Di[30]}
N 5420 -2970 5440 -2970 {
lab=Di[31]}
N 5510 -3650 5510 -3630 {
lab=CLK_buf}
N 5530 -3650 5530 -3630 {
lab=SEL[7]}
N 5550 -3650 5550 -3630 {
lab=we0_buf}
N 5570 -3650 5570 -3630 {
lab=we1_buf}
N 5590 -3650 5590 -3630 {
lab=we2_buf}
N 5610 -3650 5610 -3630 {
lab=we3_buf}
N 5640 -3650 5640 -3630 {
lab=VDD}
N 5660 -3650 5660 -3630 {
lab=VSS}
N 5420 -2690 5440 -2690 {
lab=di0_buf}
N 5420 -2670 5440 -2670 {
lab=di1_buf}
N 5420 -2650 5440 -2650 {
lab=di2_buf}
N 5420 -2630 5440 -2630 {
lab=di3_buf}
N 5420 -2610 5440 -2610 {
lab=di4_buf}
N 5420 -2590 5440 -2590 {
lab=di5_buf}
N 5420 -2570 5440 -2570 {
lab=di6_buf}
N 5420 -2550 5440 -2550 {
lab=di7_buf}
N 5420 -2530 5440 -2530 {
lab=di8_buf}
N 5420 -2510 5440 -2510 {
lab=di9_buf}
N 5420 -2490 5440 -2490 {
lab=di10_buf}
N 5420 -2470 5440 -2470 {
lab=di11_buf}
N 5420 -2450 5440 -2450 {
lab=di12_buf}
N 5420 -2430 5440 -2430 {
lab=di13_buf}
N 5420 -2410 5440 -2410 {
lab=di14_buf}
N 5420 -2390 5440 -2390 {
lab=di15_buf}
N 5420 -2370 5440 -2370 {
lab=di16_buf}
N 5420 -2350 5440 -2350 {
lab=Di[17]}
N 5420 -2330 5440 -2330 {
lab=Di[18]}
N 5420 -2310 5440 -2310 {
lab=Di[19]}
N 5420 -2290 5440 -2290 {
lab=Di[20]}
N 5420 -2270 5440 -2270 {
lab=Di[21]}
N 5420 -2250 5440 -2250 {
lab=Di[22]}
N 5420 -2230 5440 -2230 {
lab=Di[23]}
N 5420 -2210 5440 -2210 {
lab=Di[24]}
N 5420 -2190 5440 -2190 {
lab=Di[25]}
N 5420 -2170 5440 -2170 {
lab=Di[26]}
N 5420 -2150 5440 -2150 {
lab=Di[27]}
N 5420 -2130 5440 -2130 {
lab=Di[28]}
N 5420 -2110 5440 -2110 {
lab=Di[29]}
N 5420 -2090 5440 -2090 {
lab=Di[30]}
N 5420 -2070 5440 -2070 {
lab=Di[31]}
N 5510 -2750 5510 -2730 {
lab=CLK_buf}
N 5530 -2750 5530 -2730 {
lab=SEL[15]}
N 5550 -2750 5550 -2730 {
lab=we0_buf}
N 5570 -2750 5570 -2730 {
lab=we1_buf}
N 5590 -2750 5590 -2730 {
lab=we2_buf}
N 5610 -2750 5610 -2730 {
lab=we3_buf}
N 5640 -2750 5640 -2730 {
lab=VDD}
N 5660 -2750 5660 -2730 {
lab=VSS}
N 4900 -2690 4920 -2690 {
lab=di0_buf}
N 4900 -2670 4920 -2670 {
lab=di1_buf}
N 4900 -2650 4920 -2650 {
lab=di2_buf}
N 4900 -2630 4920 -2630 {
lab=di3_buf}
N 4900 -2610 4920 -2610 {
lab=di4_buf}
N 4900 -2590 4920 -2590 {
lab=di5_buf}
N 4900 -2570 4920 -2570 {
lab=di6_buf}
N 4900 -2550 4920 -2550 {
lab=di7_buf}
N 4900 -2530 4920 -2530 {
lab=di8_buf}
N 4900 -2510 4920 -2510 {
lab=di9_buf}
N 4900 -2490 4920 -2490 {
lab=di10_buf}
N 4900 -2470 4920 -2470 {
lab=di11_buf}
N 4900 -2450 4920 -2450 {
lab=di12_buf}
N 4900 -2430 4920 -2430 {
lab=di13_buf}
N 4900 -2410 4920 -2410 {
lab=di14_buf}
N 4900 -2390 4920 -2390 {
lab=di15_buf}
N 4900 -2370 4920 -2370 {
lab=di16_buf}
N 4900 -2350 4920 -2350 {
lab=Di[17]}
N 4900 -2330 4920 -2330 {
lab=Di[18]}
N 4900 -2310 4920 -2310 {
lab=Di[19]}
N 4900 -2290 4920 -2290 {
lab=Di[20]}
N 4900 -2270 4920 -2270 {
lab=Di[21]}
N 4900 -2250 4920 -2250 {
lab=Di[22]}
N 4900 -2230 4920 -2230 {
lab=Di[23]}
N 4900 -2210 4920 -2210 {
lab=Di[24]}
N 4900 -2190 4920 -2190 {
lab=Di[25]}
N 4900 -2170 4920 -2170 {
lab=Di[26]}
N 4900 -2150 4920 -2150 {
lab=Di[27]}
N 4900 -2130 4920 -2130 {
lab=Di[28]}
N 4900 -2110 4920 -2110 {
lab=Di[29]}
N 4900 -2090 4920 -2090 {
lab=Di[30]}
N 4900 -2070 4920 -2070 {
lab=Di[31]}
N 4990 -2750 4990 -2730 {
lab=CLK_buf}
N 5010 -2750 5010 -2730 {
lab=SEL[14]}
N 5030 -2750 5030 -2730 {
lab=we0_buf}
N 5050 -2750 5050 -2730 {
lab=we1_buf}
N 5070 -2750 5070 -2730 {
lab=we2_buf}
N 5090 -2750 5090 -2730 {
lab=we3_buf}
N 5120 -2750 5120 -2730 {
lab=VDD}
N 5140 -2750 5140 -2730 {
lab=VSS}
N 4360 -2690 4380 -2690 {
lab=di0_buf}
N 4360 -2670 4380 -2670 {
lab=di1_buf}
N 4360 -2650 4380 -2650 {
lab=di2_buf}
N 4360 -2630 4380 -2630 {
lab=di3_buf}
N 4360 -2610 4380 -2610 {
lab=di4_buf}
N 4360 -2590 4380 -2590 {
lab=di5_buf}
N 4360 -2570 4380 -2570 {
lab=di6_buf}
N 4360 -2550 4380 -2550 {
lab=di7_buf}
N 4360 -2530 4380 -2530 {
lab=di8_buf}
N 4360 -2510 4380 -2510 {
lab=di9_buf}
N 4360 -2490 4380 -2490 {
lab=di10_buf}
N 4360 -2470 4380 -2470 {
lab=di11_buf}
N 4360 -2450 4380 -2450 {
lab=di12_buf}
N 4360 -2430 4380 -2430 {
lab=di13_buf}
N 4360 -2410 4380 -2410 {
lab=di14_buf}
N 4360 -2390 4380 -2390 {
lab=di15_buf}
N 4360 -2370 4380 -2370 {
lab=di16_buf}
N 4360 -2350 4380 -2350 {
lab=Di[17]}
N 4360 -2330 4380 -2330 {
lab=Di[18]}
N 4360 -2310 4380 -2310 {
lab=Di[19]}
N 4360 -2290 4380 -2290 {
lab=Di[20]}
N 4360 -2270 4380 -2270 {
lab=Di[21]}
N 4360 -2250 4380 -2250 {
lab=Di[22]}
N 4360 -2230 4380 -2230 {
lab=Di[23]}
N 4360 -2210 4380 -2210 {
lab=Di[24]}
N 4360 -2190 4380 -2190 {
lab=Di[25]}
N 4360 -2170 4380 -2170 {
lab=Di[26]}
N 4360 -2150 4380 -2150 {
lab=Di[27]}
N 4360 -2130 4380 -2130 {
lab=Di[28]}
N 4360 -2110 4380 -2110 {
lab=Di[29]}
N 4360 -2090 4380 -2090 {
lab=Di[30]}
N 4360 -2070 4380 -2070 {
lab=Di[31]}
N 4450 -2750 4450 -2730 {
lab=CLK_buf}
N 4470 -2750 4470 -2730 {
lab=SEL[13]}
N 4490 -2750 4490 -2730 {
lab=we0_buf}
N 4510 -2750 4510 -2730 {
lab=we1_buf}
N 4530 -2750 4530 -2730 {
lab=we2_buf}
N 4550 -2750 4550 -2730 {
lab=we3_buf}
N 4580 -2750 4580 -2730 {
lab=VDD}
N 4600 -2750 4600 -2730 {
lab=VSS}
N 3840 -2690 3860 -2690 {
lab=di0_buf}
N 3840 -2670 3860 -2670 {
lab=di1_buf}
N 3840 -2650 3860 -2650 {
lab=di2_buf}
N 3840 -2630 3860 -2630 {
lab=di3_buf}
N 3840 -2610 3860 -2610 {
lab=di4_buf}
N 3840 -2590 3860 -2590 {
lab=di5_buf}
N 3840 -2570 3860 -2570 {
lab=di6_buf}
N 3840 -2550 3860 -2550 {
lab=di7_buf}
N 3840 -2530 3860 -2530 {
lab=di8_buf}
N 3840 -2510 3860 -2510 {
lab=di9_buf}
N 3840 -2490 3860 -2490 {
lab=di10_buf}
N 3840 -2470 3860 -2470 {
lab=di11_buf}
N 3840 -2450 3860 -2450 {
lab=di12_buf}
N 3840 -2430 3860 -2430 {
lab=di13_buf}
N 3840 -2410 3860 -2410 {
lab=di14_buf}
N 3840 -2390 3860 -2390 {
lab=di15_buf}
N 3840 -2370 3860 -2370 {
lab=di16_buf}
N 3840 -2350 3860 -2350 {
lab=Di[17]}
N 3840 -2330 3860 -2330 {
lab=Di[18]}
N 3840 -2310 3860 -2310 {
lab=Di[19]}
N 3840 -2290 3860 -2290 {
lab=Di[20]}
N 3840 -2270 3860 -2270 {
lab=Di[21]}
N 3840 -2250 3860 -2250 {
lab=Di[22]}
N 3840 -2230 3860 -2230 {
lab=Di[23]}
N 3840 -2210 3860 -2210 {
lab=Di[24]}
N 3840 -2190 3860 -2190 {
lab=Di[25]}
N 3840 -2170 3860 -2170 {
lab=Di[26]}
N 3840 -2150 3860 -2150 {
lab=Di[27]}
N 3840 -2130 3860 -2130 {
lab=Di[28]}
N 3840 -2110 3860 -2110 {
lab=Di[29]}
N 3840 -2090 3860 -2090 {
lab=Di[30]}
N 3840 -2070 3860 -2070 {
lab=Di[31]}
N 3930 -2750 3930 -2730 {
lab=CLK_buf}
N 3950 -2750 3950 -2730 {
lab=SEL[12]}
N 3970 -2750 3970 -2730 {
lab=we0_buf}
N 3990 -2750 3990 -2730 {
lab=we1_buf}
N 4010 -2750 4010 -2730 {
lab=we2_buf}
N 4030 -2750 4030 -2730 {
lab=we3_buf}
N 4060 -2750 4060 -2730 {
lab=VDD}
N 4080 -2750 4080 -2730 {
lab=VSS}
N 3320 -2690 3340 -2690 {
lab=di0_buf}
N 3320 -2670 3340 -2670 {
lab=di1_buf}
N 3320 -2650 3340 -2650 {
lab=di2_buf}
N 3320 -2630 3340 -2630 {
lab=di3_buf}
N 3320 -2610 3340 -2610 {
lab=di4_buf}
N 3320 -2590 3340 -2590 {
lab=di5_buf}
N 3320 -2570 3340 -2570 {
lab=di6_buf}
N 3320 -2550 3340 -2550 {
lab=di7_buf}
N 3320 -2530 3340 -2530 {
lab=di8_buf}
N 3320 -2510 3340 -2510 {
lab=di9_buf}
N 3320 -2490 3340 -2490 {
lab=di10_buf}
N 3320 -2470 3340 -2470 {
lab=di11_buf}
N 3320 -2450 3340 -2450 {
lab=di12_buf}
N 3320 -2430 3340 -2430 {
lab=di13_buf}
N 3320 -2410 3340 -2410 {
lab=di14_buf}
N 3320 -2390 3340 -2390 {
lab=di15_buf}
N 3320 -2370 3340 -2370 {
lab=di16_buf}
N 3320 -2350 3340 -2350 {
lab=Di[17]}
N 3320 -2330 3340 -2330 {
lab=Di[18]}
N 3320 -2310 3340 -2310 {
lab=Di[19]}
N 3320 -2290 3340 -2290 {
lab=Di[20]}
N 3320 -2270 3340 -2270 {
lab=Di[21]}
N 3320 -2250 3340 -2250 {
lab=Di[22]}
N 3320 -2230 3340 -2230 {
lab=Di[23]}
N 3320 -2210 3340 -2210 {
lab=Di[24]}
N 3320 -2190 3340 -2190 {
lab=Di[25]}
N 3320 -2170 3340 -2170 {
lab=Di[26]}
N 3320 -2150 3340 -2150 {
lab=Di[27]}
N 3320 -2130 3340 -2130 {
lab=Di[28]}
N 3320 -2110 3340 -2110 {
lab=Di[29]}
N 3320 -2090 3340 -2090 {
lab=Di[30]}
N 3320 -2070 3340 -2070 {
lab=Di[31]}
N 3410 -2750 3410 -2730 {
lab=CLK_buf}
N 3430 -2750 3430 -2730 {
lab=SEL[11]}
N 3450 -2750 3450 -2730 {
lab=we0_buf}
N 3470 -2750 3470 -2730 {
lab=we1_buf}
N 3490 -2750 3490 -2730 {
lab=we2_buf}
N 3510 -2750 3510 -2730 {
lab=we3_buf}
N 3540 -2750 3540 -2730 {
lab=VDD}
N 3560 -2750 3560 -2730 {
lab=VSS}
N 2800 -2690 2820 -2690 {
lab=di0_buf}
N 2800 -2670 2820 -2670 {
lab=di1_buf}
N 2800 -2650 2820 -2650 {
lab=di2_buf}
N 2800 -2630 2820 -2630 {
lab=di3_buf}
N 2800 -2610 2820 -2610 {
lab=di4_buf}
N 2800 -2590 2820 -2590 {
lab=di5_buf}
N 2800 -2570 2820 -2570 {
lab=di6_buf}
N 2800 -2550 2820 -2550 {
lab=di7_buf}
N 2800 -2530 2820 -2530 {
lab=di8_buf}
N 2800 -2510 2820 -2510 {
lab=di9_buf}
N 2800 -2490 2820 -2490 {
lab=di10_buf}
N 2800 -2470 2820 -2470 {
lab=di11_buf}
N 2800 -2450 2820 -2450 {
lab=di12_buf}
N 2800 -2430 2820 -2430 {
lab=di13_buf}
N 2800 -2410 2820 -2410 {
lab=di14_buf}
N 2800 -2390 2820 -2390 {
lab=di15_buf}
N 2800 -2370 2820 -2370 {
lab=di16_buf}
N 2800 -2350 2820 -2350 {
lab=Di[17]}
N 2800 -2330 2820 -2330 {
lab=Di[18]}
N 2800 -2310 2820 -2310 {
lab=Di[19]}
N 2800 -2290 2820 -2290 {
lab=Di[20]}
N 2800 -2270 2820 -2270 {
lab=Di[21]}
N 2800 -2250 2820 -2250 {
lab=Di[22]}
N 2800 -2230 2820 -2230 {
lab=Di[23]}
N 2800 -2210 2820 -2210 {
lab=Di[24]}
N 2800 -2190 2820 -2190 {
lab=Di[25]}
N 2800 -2170 2820 -2170 {
lab=Di[26]}
N 2800 -2150 2820 -2150 {
lab=Di[27]}
N 2800 -2130 2820 -2130 {
lab=Di[28]}
N 2800 -2110 2820 -2110 {
lab=Di[29]}
N 2800 -2090 2820 -2090 {
lab=Di[30]}
N 2800 -2070 2820 -2070 {
lab=Di[31]}
N 2890 -2750 2890 -2730 {
lab=CLK_buf}
N 2910 -2750 2910 -2730 {
lab=SEL[10]}
N 2930 -2750 2930 -2730 {
lab=we0_buf}
N 2950 -2750 2950 -2730 {
lab=we1_buf}
N 2970 -2750 2970 -2730 {
lab=we2_buf}
N 2990 -2750 2990 -2730 {
lab=we3_buf}
N 3020 -2750 3020 -2730 {
lab=VDD}
N 3040 -2750 3040 -2730 {
lab=VSS}
N 2260 -2690 2280 -2690 {
lab=di0_buf}
N 2260 -2670 2280 -2670 {
lab=di1_buf}
N 2260 -2650 2280 -2650 {
lab=di2_buf}
N 2260 -2630 2280 -2630 {
lab=di3_buf}
N 2260 -2610 2280 -2610 {
lab=di4_buf}
N 2260 -2590 2280 -2590 {
lab=di5_buf}
N 2260 -2570 2280 -2570 {
lab=di6_buf}
N 2260 -2550 2280 -2550 {
lab=di7_buf}
N 2260 -2530 2280 -2530 {
lab=di8_buf}
N 2260 -2510 2280 -2510 {
lab=di9_buf}
N 2260 -2490 2280 -2490 {
lab=di10_buf}
N 2260 -2470 2280 -2470 {
lab=di11_buf}
N 2260 -2450 2280 -2450 {
lab=di12_buf}
N 2260 -2430 2280 -2430 {
lab=di13_buf}
N 2260 -2410 2280 -2410 {
lab=di14_buf}
N 2260 -2390 2280 -2390 {
lab=di15_buf}
N 2260 -2370 2280 -2370 {
lab=di16_buf}
N 2260 -2350 2280 -2350 {
lab=Di[17]}
N 2260 -2330 2280 -2330 {
lab=Di[18]}
N 2260 -2310 2280 -2310 {
lab=Di[19]}
N 2260 -2290 2280 -2290 {
lab=Di[20]}
N 2260 -2270 2280 -2270 {
lab=Di[21]}
N 2260 -2250 2280 -2250 {
lab=Di[22]}
N 2260 -2230 2280 -2230 {
lab=Di[23]}
N 2260 -2210 2280 -2210 {
lab=Di[24]}
N 2260 -2190 2280 -2190 {
lab=Di[25]}
N 2260 -2170 2280 -2170 {
lab=Di[26]}
N 2260 -2150 2280 -2150 {
lab=Di[27]}
N 2260 -2130 2280 -2130 {
lab=Di[28]}
N 2260 -2110 2280 -2110 {
lab=Di[29]}
N 2260 -2090 2280 -2090 {
lab=Di[30]}
N 2260 -2070 2280 -2070 {
lab=Di[31]}
N 2350 -2750 2350 -2730 {
lab=CLK_buf}
N 2370 -2750 2370 -2730 {
lab=SEL[9]}
N 2390 -2750 2390 -2730 {
lab=we0_buf}
N 2410 -2750 2410 -2730 {
lab=we1_buf}
N 2430 -2750 2430 -2730 {
lab=we2_buf}
N 2450 -2750 2450 -2730 {
lab=we3_buf}
N 2480 -2750 2480 -2730 {
lab=VDD}
N 2500 -2750 2500 -2730 {
lab=VSS}
N 1740 -2690 1760 -2690 {
lab=di0_buf}
N 1740 -2670 1760 -2670 {
lab=di1_buf}
N 1740 -2650 1760 -2650 {
lab=di2_buf}
N 1740 -2630 1760 -2630 {
lab=di3_buf}
N 1740 -2610 1760 -2610 {
lab=di4_buf}
N 1740 -2590 1760 -2590 {
lab=di5_buf}
N 1740 -2570 1760 -2570 {
lab=di6_buf}
N 1740 -2550 1760 -2550 {
lab=di7_buf}
N 1740 -2530 1760 -2530 {
lab=di8_buf}
N 1740 -2510 1760 -2510 {
lab=di9_buf}
N 1740 -2490 1760 -2490 {
lab=di10_buf}
N 1740 -2470 1760 -2470 {
lab=di11_buf}
N 1740 -2450 1760 -2450 {
lab=di12_buf}
N 1740 -2430 1760 -2430 {
lab=di13_buf}
N 1740 -2410 1760 -2410 {
lab=di14_buf}
N 1740 -2390 1760 -2390 {
lab=di15_buf}
N 1740 -2370 1760 -2370 {
lab=di16_buf}
N 1740 -2350 1760 -2350 {
lab=Di[17]}
N 1740 -2330 1760 -2330 {
lab=Di[18]}
N 1740 -2310 1760 -2310 {
lab=Di[19]}
N 1740 -2290 1760 -2290 {
lab=Di[20]}
N 1740 -2270 1760 -2270 {
lab=Di[21]}
N 1740 -2250 1760 -2250 {
lab=Di[22]}
N 1740 -2230 1760 -2230 {
lab=Di[23]}
N 1740 -2210 1760 -2210 {
lab=Di[24]}
N 1740 -2190 1760 -2190 {
lab=Di[25]}
N 1740 -2170 1760 -2170 {
lab=Di[26]}
N 1740 -2150 1760 -2150 {
lab=Di[27]}
N 1740 -2130 1760 -2130 {
lab=Di[28]}
N 1740 -2110 1760 -2110 {
lab=Di[29]}
N 1740 -2090 1760 -2090 {
lab=Di[30]}
N 1740 -2070 1760 -2070 {
lab=Di[31]}
N 1830 -2750 1830 -2730 {
lab=CLK_buf}
N 1850 -2750 1850 -2730 {
lab=SEL[8]}
N 1870 -2750 1870 -2730 {
lab=we0_buf}
N 1890 -2750 1890 -2730 {
lab=we1_buf}
N 1910 -2750 1910 -2730 {
lab=we2_buf}
N 1930 -2750 1930 -2730 {
lab=we3_buf}
N 1960 -2750 1960 -2730 {
lab=VDD}
N 1980 -2750 1980 -2730 {
lab=VSS}
N 1750 -1740 1770 -1740 {
lab=di0_buf}
N 1750 -1720 1770 -1720 {
lab=di1_buf}
N 1750 -1700 1770 -1700 {
lab=di2_buf}
N 1750 -1680 1770 -1680 {
lab=di3_buf}
N 1750 -1660 1770 -1660 {
lab=di4_buf}
N 1750 -1640 1770 -1640 {
lab=di5_buf}
N 1750 -1620 1770 -1620 {
lab=di6_buf}
N 1750 -1600 1770 -1600 {
lab=di7_buf}
N 1750 -1580 1770 -1580 {
lab=di8_buf}
N 1750 -1560 1770 -1560 {
lab=di9_buf}
N 1750 -1540 1770 -1540 {
lab=di10_buf}
N 1750 -1520 1770 -1520 {
lab=di11_buf}
N 1750 -1500 1770 -1500 {
lab=di12_buf}
N 1750 -1480 1770 -1480 {
lab=di13_buf}
N 1750 -1460 1770 -1460 {
lab=di14_buf}
N 1750 -1440 1770 -1440 {
lab=di15_buf}
N 1750 -1420 1770 -1420 {
lab=di16_buf}
N 1750 -1400 1770 -1400 {
lab=Di[17]}
N 1750 -1380 1770 -1380 {
lab=Di[18]}
N 1750 -1360 1770 -1360 {
lab=Di[19]}
N 1750 -1340 1770 -1340 {
lab=Di[20]}
N 1750 -1320 1770 -1320 {
lab=Di[21]}
N 1750 -1300 1770 -1300 {
lab=Di[22]}
N 1750 -1280 1770 -1280 {
lab=Di[23]}
N 1750 -1260 1770 -1260 {
lab=Di[24]}
N 1750 -1240 1770 -1240 {
lab=Di[25]}
N 1750 -1220 1770 -1220 {
lab=Di[26]}
N 1750 -1200 1770 -1200 {
lab=Di[27]}
N 1750 -1180 1770 -1180 {
lab=Di[28]}
N 1750 -1160 1770 -1160 {
lab=Di[29]}
N 1750 -1140 1770 -1140 {
lab=Di[30]}
N 1750 -1120 1770 -1120 {
lab=Di[31]}
N 1840 -1800 1840 -1780 {
lab=CLK_buf}
N 1860 -1800 1860 -1780 {
lab=SEL[16]}
N 1880 -1800 1880 -1780 {
lab=we0_buf}
N 1900 -1800 1900 -1780 {
lab=we1_buf}
N 1920 -1800 1920 -1780 {
lab=we2_buf}
N 1940 -1800 1940 -1780 {
lab=we3_buf}
N 1970 -1800 1970 -1780 {
lab=VDD}
N 1990 -1800 1990 -1780 {
lab=VSS}
N 2270 -1740 2290 -1740 {
lab=di0_buf}
N 2270 -1720 2290 -1720 {
lab=di1_buf}
N 2270 -1700 2290 -1700 {
lab=di2_buf}
N 2270 -1680 2290 -1680 {
lab=di3_buf}
N 2270 -1660 2290 -1660 {
lab=di4_buf}
N 2270 -1640 2290 -1640 {
lab=di5_buf}
N 2270 -1620 2290 -1620 {
lab=di6_buf}
N 2270 -1600 2290 -1600 {
lab=di7_buf}
N 2270 -1580 2290 -1580 {
lab=di8_buf}
N 2270 -1560 2290 -1560 {
lab=di9_buf}
N 2270 -1540 2290 -1540 {
lab=di10_buf}
N 2270 -1520 2290 -1520 {
lab=di11_buf}
N 2270 -1500 2290 -1500 {
lab=di12_buf}
N 2270 -1480 2290 -1480 {
lab=di13_buf}
N 2270 -1460 2290 -1460 {
lab=di14_buf}
N 2270 -1440 2290 -1440 {
lab=di15_buf}
N 2270 -1420 2290 -1420 {
lab=di16_buf}
N 2270 -1400 2290 -1400 {
lab=Di[17]}
N 2270 -1380 2290 -1380 {
lab=Di[18]}
N 2270 -1360 2290 -1360 {
lab=Di[19]}
N 2270 -1340 2290 -1340 {
lab=Di[20]}
N 2270 -1320 2290 -1320 {
lab=Di[21]}
N 2270 -1300 2290 -1300 {
lab=Di[22]}
N 2270 -1280 2290 -1280 {
lab=Di[23]}
N 2270 -1260 2290 -1260 {
lab=Di[24]}
N 2270 -1240 2290 -1240 {
lab=Di[25]}
N 2270 -1220 2290 -1220 {
lab=Di[26]}
N 2270 -1200 2290 -1200 {
lab=Di[27]}
N 2270 -1180 2290 -1180 {
lab=Di[28]}
N 2270 -1160 2290 -1160 {
lab=Di[29]}
N 2270 -1140 2290 -1140 {
lab=Di[30]}
N 2270 -1120 2290 -1120 {
lab=Di[31]}
N 2360 -1800 2360 -1780 {
lab=CLK_buf}
N 2380 -1800 2380 -1780 {
lab=SEL[17]}
N 2400 -1800 2400 -1780 {
lab=we0_buf}
N 2420 -1800 2420 -1780 {
lab=we1_buf}
N 2440 -1800 2440 -1780 {
lab=we2_buf}
N 2460 -1800 2460 -1780 {
lab=we3_buf}
N 2490 -1800 2490 -1780 {
lab=VDD}
N 2510 -1800 2510 -1780 {
lab=VSS}
N 2810 -1740 2830 -1740 {
lab=di0_buf}
N 2810 -1720 2830 -1720 {
lab=di1_buf}
N 2810 -1700 2830 -1700 {
lab=di2_buf}
N 2810 -1680 2830 -1680 {
lab=di3_buf}
N 2810 -1660 2830 -1660 {
lab=di4_buf}
N 2810 -1640 2830 -1640 {
lab=di5_buf}
N 2810 -1620 2830 -1620 {
lab=di6_buf}
N 2810 -1600 2830 -1600 {
lab=di7_buf}
N 2810 -1580 2830 -1580 {
lab=di8_buf}
N 2810 -1560 2830 -1560 {
lab=di9_buf}
N 2810 -1540 2830 -1540 {
lab=di10_buf}
N 2810 -1520 2830 -1520 {
lab=di11_buf}
N 2810 -1500 2830 -1500 {
lab=di12_buf}
N 2810 -1480 2830 -1480 {
lab=di13_buf}
N 2810 -1460 2830 -1460 {
lab=di14_buf}
N 2810 -1440 2830 -1440 {
lab=di15_buf}
N 2810 -1420 2830 -1420 {
lab=di16_buf}
N 2810 -1400 2830 -1400 {
lab=Di[17]}
N 2810 -1380 2830 -1380 {
lab=Di[18]}
N 2810 -1360 2830 -1360 {
lab=Di[19]}
N 2810 -1340 2830 -1340 {
lab=Di[20]}
N 2810 -1320 2830 -1320 {
lab=Di[21]}
N 2810 -1300 2830 -1300 {
lab=Di[22]}
N 2810 -1280 2830 -1280 {
lab=Di[23]}
N 2810 -1260 2830 -1260 {
lab=Di[24]}
N 2810 -1240 2830 -1240 {
lab=Di[25]}
N 2810 -1220 2830 -1220 {
lab=Di[26]}
N 2810 -1200 2830 -1200 {
lab=Di[27]}
N 2810 -1180 2830 -1180 {
lab=Di[28]}
N 2810 -1160 2830 -1160 {
lab=Di[29]}
N 2810 -1140 2830 -1140 {
lab=Di[30]}
N 2810 -1120 2830 -1120 {
lab=Di[31]}
N 2900 -1800 2900 -1780 {
lab=CLK_buf}
N 2920 -1800 2920 -1780 {
lab=SEL[18]}
N 2940 -1800 2940 -1780 {
lab=we0_buf}
N 2960 -1800 2960 -1780 {
lab=we1_buf}
N 2980 -1800 2980 -1780 {
lab=we2_buf}
N 3000 -1800 3000 -1780 {
lab=we3_buf}
N 3030 -1800 3030 -1780 {
lab=VDD}
N 3050 -1800 3050 -1780 {
lab=VSS}
N 3330 -1740 3350 -1740 {
lab=di0_buf}
N 3330 -1720 3350 -1720 {
lab=di1_buf}
N 3330 -1700 3350 -1700 {
lab=di2_buf}
N 3330 -1680 3350 -1680 {
lab=di3_buf}
N 3330 -1660 3350 -1660 {
lab=di4_buf}
N 3330 -1640 3350 -1640 {
lab=di5_buf}
N 3330 -1620 3350 -1620 {
lab=di6_buf}
N 3330 -1600 3350 -1600 {
lab=di7_buf}
N 3330 -1580 3350 -1580 {
lab=di8_buf}
N 3330 -1560 3350 -1560 {
lab=di9_buf}
N 3330 -1540 3350 -1540 {
lab=di10_buf}
N 3330 -1520 3350 -1520 {
lab=di11_buf}
N 3330 -1500 3350 -1500 {
lab=di12_buf}
N 3330 -1480 3350 -1480 {
lab=di13_buf}
N 3330 -1460 3350 -1460 {
lab=di14_buf}
N 3330 -1440 3350 -1440 {
lab=di15_buf}
N 3330 -1420 3350 -1420 {
lab=di16_buf}
N 3330 -1400 3350 -1400 {
lab=Di[17]}
N 3330 -1380 3350 -1380 {
lab=Di[18]}
N 3330 -1360 3350 -1360 {
lab=Di[19]}
N 3330 -1340 3350 -1340 {
lab=Di[20]}
N 3330 -1320 3350 -1320 {
lab=Di[21]}
N 3330 -1300 3350 -1300 {
lab=Di[22]}
N 3330 -1280 3350 -1280 {
lab=Di[23]}
N 3330 -1260 3350 -1260 {
lab=Di[24]}
N 3330 -1240 3350 -1240 {
lab=Di[25]}
N 3330 -1220 3350 -1220 {
lab=Di[26]}
N 3330 -1200 3350 -1200 {
lab=Di[27]}
N 3330 -1180 3350 -1180 {
lab=Di[28]}
N 3330 -1160 3350 -1160 {
lab=Di[29]}
N 3330 -1140 3350 -1140 {
lab=Di[30]}
N 3330 -1120 3350 -1120 {
lab=Di[31]}
N 3420 -1800 3420 -1780 {
lab=CLK_buf}
N 3440 -1800 3440 -1780 {
lab=SEL[19]}
N 3460 -1800 3460 -1780 {
lab=we0_buf}
N 3480 -1800 3480 -1780 {
lab=we1_buf}
N 3500 -1800 3500 -1780 {
lab=we2_buf}
N 3520 -1800 3520 -1780 {
lab=we3_buf}
N 3550 -1800 3550 -1780 {
lab=VDD}
N 3570 -1800 3570 -1780 {
lab=VSS}
N 3850 -1740 3870 -1740 {
lab=di0_buf}
N 3850 -1720 3870 -1720 {
lab=di1_buf}
N 3850 -1700 3870 -1700 {
lab=di2_buf}
N 3850 -1680 3870 -1680 {
lab=di3_buf}
N 3850 -1660 3870 -1660 {
lab=di4_buf}
N 3850 -1640 3870 -1640 {
lab=di5_buf}
N 3850 -1620 3870 -1620 {
lab=di6_buf}
N 3850 -1600 3870 -1600 {
lab=di7_buf}
N 3850 -1580 3870 -1580 {
lab=di8_buf}
N 3850 -1560 3870 -1560 {
lab=di9_buf}
N 3850 -1540 3870 -1540 {
lab=di10_buf}
N 3850 -1520 3870 -1520 {
lab=di11_buf}
N 3850 -1500 3870 -1500 {
lab=di12_buf}
N 3850 -1480 3870 -1480 {
lab=di13_buf}
N 3850 -1460 3870 -1460 {
lab=di14_buf}
N 3850 -1440 3870 -1440 {
lab=di15_buf}
N 3850 -1420 3870 -1420 {
lab=di16_buf}
N 3850 -1400 3870 -1400 {
lab=Di[17]}
N 3850 -1380 3870 -1380 {
lab=Di[18]}
N 3850 -1360 3870 -1360 {
lab=Di[19]}
N 3850 -1340 3870 -1340 {
lab=Di[20]}
N 3850 -1320 3870 -1320 {
lab=Di[21]}
N 3850 -1300 3870 -1300 {
lab=Di[22]}
N 3850 -1280 3870 -1280 {
lab=Di[23]}
N 3850 -1260 3870 -1260 {
lab=Di[24]}
N 3850 -1240 3870 -1240 {
lab=Di[25]}
N 3850 -1220 3870 -1220 {
lab=Di[26]}
N 3850 -1200 3870 -1200 {
lab=Di[27]}
N 3850 -1180 3870 -1180 {
lab=Di[28]}
N 3850 -1160 3870 -1160 {
lab=Di[29]}
N 3850 -1140 3870 -1140 {
lab=Di[30]}
N 3850 -1120 3870 -1120 {
lab=Di[31]}
N 3940 -1800 3940 -1780 {
lab=CLK_buf}
N 3960 -1800 3960 -1780 {
lab=SEL[20]}
N 3980 -1800 3980 -1780 {
lab=we0_buf}
N 4000 -1800 4000 -1780 {
lab=we1_buf}
N 4020 -1800 4020 -1780 {
lab=we2_buf}
N 4040 -1800 4040 -1780 {
lab=we3_buf}
N 4070 -1800 4070 -1780 {
lab=VDD}
N 4090 -1800 4090 -1780 {
lab=VSS}
N 4370 -1740 4390 -1740 {
lab=di0_buf}
N 4370 -1720 4390 -1720 {
lab=di1_buf}
N 4370 -1700 4390 -1700 {
lab=di2_buf}
N 4370 -1680 4390 -1680 {
lab=di3_buf}
N 4370 -1660 4390 -1660 {
lab=di4_buf}
N 4370 -1640 4390 -1640 {
lab=di5_buf}
N 4370 -1620 4390 -1620 {
lab=di6_buf}
N 4370 -1600 4390 -1600 {
lab=di7_buf}
N 4370 -1580 4390 -1580 {
lab=di8_buf}
N 4370 -1560 4390 -1560 {
lab=di9_buf}
N 4370 -1540 4390 -1540 {
lab=di10_buf}
N 4370 -1520 4390 -1520 {
lab=di11_buf}
N 4370 -1500 4390 -1500 {
lab=di12_buf}
N 4370 -1480 4390 -1480 {
lab=di13_buf}
N 4370 -1460 4390 -1460 {
lab=di14_buf}
N 4370 -1440 4390 -1440 {
lab=di15_buf}
N 4370 -1420 4390 -1420 {
lab=di16_buf}
N 4370 -1400 4390 -1400 {
lab=Di[17]}
N 4370 -1380 4390 -1380 {
lab=Di[18]}
N 4370 -1360 4390 -1360 {
lab=Di[19]}
N 4370 -1340 4390 -1340 {
lab=Di[20]}
N 4370 -1320 4390 -1320 {
lab=Di[21]}
N 4370 -1300 4390 -1300 {
lab=Di[22]}
N 4370 -1280 4390 -1280 {
lab=Di[23]}
N 4370 -1260 4390 -1260 {
lab=Di[24]}
N 4370 -1240 4390 -1240 {
lab=Di[25]}
N 4370 -1220 4390 -1220 {
lab=Di[26]}
N 4370 -1200 4390 -1200 {
lab=Di[27]}
N 4370 -1180 4390 -1180 {
lab=Di[28]}
N 4370 -1160 4390 -1160 {
lab=Di[29]}
N 4370 -1140 4390 -1140 {
lab=Di[30]}
N 4370 -1120 4390 -1120 {
lab=Di[31]}
N 4460 -1800 4460 -1780 {
lab=CLK_buf}
N 4480 -1800 4480 -1780 {
lab=SEL[21]}
N 4500 -1800 4500 -1780 {
lab=we0_buf}
N 4520 -1800 4520 -1780 {
lab=we1_buf}
N 4540 -1800 4540 -1780 {
lab=we2_buf}
N 4560 -1800 4560 -1780 {
lab=we3_buf}
N 4590 -1800 4590 -1780 {
lab=VDD}
N 4610 -1800 4610 -1780 {
lab=VSS}
N 4910 -1740 4930 -1740 {
lab=di0_buf}
N 4910 -1720 4930 -1720 {
lab=di1_buf}
N 4910 -1700 4930 -1700 {
lab=di2_buf}
N 4910 -1680 4930 -1680 {
lab=di3_buf}
N 4910 -1660 4930 -1660 {
lab=di4_buf}
N 4910 -1640 4930 -1640 {
lab=di5_buf}
N 4910 -1620 4930 -1620 {
lab=di6_buf}
N 4910 -1600 4930 -1600 {
lab=di7_buf}
N 4910 -1580 4930 -1580 {
lab=di8_buf}
N 4910 -1560 4930 -1560 {
lab=di9_buf}
N 4910 -1540 4930 -1540 {
lab=di10_buf}
N 4910 -1520 4930 -1520 {
lab=di11_buf}
N 4910 -1500 4930 -1500 {
lab=di12_buf}
N 4910 -1480 4930 -1480 {
lab=di13_buf}
N 4910 -1460 4930 -1460 {
lab=di14_buf}
N 4910 -1440 4930 -1440 {
lab=di15_buf}
N 4910 -1420 4930 -1420 {
lab=di16_buf}
N 4910 -1400 4930 -1400 {
lab=Di[17]}
N 4910 -1380 4930 -1380 {
lab=Di[18]}
N 4910 -1360 4930 -1360 {
lab=Di[19]}
N 4910 -1340 4930 -1340 {
lab=Di[20]}
N 4910 -1320 4930 -1320 {
lab=Di[21]}
N 4910 -1300 4930 -1300 {
lab=Di[22]}
N 4910 -1280 4930 -1280 {
lab=Di[23]}
N 4910 -1260 4930 -1260 {
lab=Di[24]}
N 4910 -1240 4930 -1240 {
lab=Di[25]}
N 4910 -1220 4930 -1220 {
lab=Di[26]}
N 4910 -1200 4930 -1200 {
lab=Di[27]}
N 4910 -1180 4930 -1180 {
lab=Di[28]}
N 4910 -1160 4930 -1160 {
lab=Di[29]}
N 4910 -1140 4930 -1140 {
lab=Di[30]}
N 4910 -1120 4930 -1120 {
lab=Di[31]}
N 5000 -1800 5000 -1780 {
lab=CLK_buf}
N 5020 -1800 5020 -1780 {
lab=SEL[22]}
N 5040 -1800 5040 -1780 {
lab=we0_buf}
N 5060 -1800 5060 -1780 {
lab=we1_buf}
N 5080 -1800 5080 -1780 {
lab=we2_buf}
N 5100 -1800 5100 -1780 {
lab=we3_buf}
N 5130 -1800 5130 -1780 {
lab=VDD}
N 5150 -1800 5150 -1780 {
lab=VSS}
N 5430 -1740 5450 -1740 {
lab=di0_buf}
N 5430 -1720 5450 -1720 {
lab=di1_buf}
N 5430 -1700 5450 -1700 {
lab=di2_buf}
N 5430 -1680 5450 -1680 {
lab=di3_buf}
N 5430 -1660 5450 -1660 {
lab=di4_buf}
N 5430 -1640 5450 -1640 {
lab=di5_buf}
N 5430 -1620 5450 -1620 {
lab=di6_buf}
N 5430 -1600 5450 -1600 {
lab=di7_buf}
N 5430 -1580 5450 -1580 {
lab=di8_buf}
N 5430 -1560 5450 -1560 {
lab=di9_buf}
N 5430 -1540 5450 -1540 {
lab=di10_buf}
N 5430 -1520 5450 -1520 {
lab=di11_buf}
N 5430 -1500 5450 -1500 {
lab=di12_buf}
N 5430 -1480 5450 -1480 {
lab=di13_buf}
N 5430 -1460 5450 -1460 {
lab=di14_buf}
N 5430 -1440 5450 -1440 {
lab=di15_buf}
N 5430 -1420 5450 -1420 {
lab=di16_buf}
N 5430 -1400 5450 -1400 {
lab=Di[17]}
N 5430 -1380 5450 -1380 {
lab=Di[18]}
N 5430 -1360 5450 -1360 {
lab=Di[19]}
N 5430 -1340 5450 -1340 {
lab=Di[20]}
N 5430 -1320 5450 -1320 {
lab=Di[21]}
N 5430 -1300 5450 -1300 {
lab=Di[22]}
N 5430 -1280 5450 -1280 {
lab=Di[23]}
N 5430 -1260 5450 -1260 {
lab=Di[24]}
N 5430 -1240 5450 -1240 {
lab=Di[25]}
N 5430 -1220 5450 -1220 {
lab=Di[26]}
N 5430 -1200 5450 -1200 {
lab=Di[27]}
N 5430 -1180 5450 -1180 {
lab=Di[28]}
N 5430 -1160 5450 -1160 {
lab=Di[29]}
N 5430 -1140 5450 -1140 {
lab=Di[30]}
N 5430 -1120 5450 -1120 {
lab=Di[31]}
N 5520 -1800 5520 -1780 {
lab=CLK_buf}
N 5540 -1800 5540 -1780 {
lab=SEL[23]}
N 5560 -1800 5560 -1780 {
lab=we0_buf}
N 5580 -1800 5580 -1780 {
lab=we1_buf}
N 5600 -1800 5600 -1780 {
lab=we2_buf}
N 5620 -1800 5620 -1780 {
lab=we3_buf}
N 5650 -1800 5650 -1780 {
lab=VDD}
N 5670 -1800 5670 -1780 {
lab=VSS}
N 5430 -840 5450 -840 {
lab=di0_buf}
N 5430 -820 5450 -820 {
lab=di1_buf}
N 5430 -800 5450 -800 {
lab=di2_buf}
N 5430 -780 5450 -780 {
lab=di3_buf}
N 5430 -760 5450 -760 {
lab=di4_buf}
N 5430 -740 5450 -740 {
lab=di5_buf}
N 5430 -720 5450 -720 {
lab=di6_buf}
N 5430 -700 5450 -700 {
lab=di7_buf}
N 5430 -680 5450 -680 {
lab=di8_buf}
N 5430 -660 5450 -660 {
lab=di9_buf}
N 5430 -640 5450 -640 {
lab=di10_buf}
N 5430 -620 5450 -620 {
lab=di11_buf}
N 5430 -600 5450 -600 {
lab=di12_buf}
N 5430 -580 5450 -580 {
lab=di13_buf}
N 5430 -560 5450 -560 {
lab=di14_buf}
N 5430 -540 5450 -540 {
lab=di15_buf}
N 5430 -520 5450 -520 {
lab=di16_buf}
N 5430 -500 5450 -500 {
lab=Di[17]}
N 5430 -480 5450 -480 {
lab=Di[18]}
N 5430 -460 5450 -460 {
lab=Di[19]}
N 5430 -440 5450 -440 {
lab=Di[20]}
N 5430 -420 5450 -420 {
lab=Di[21]}
N 5430 -400 5450 -400 {
lab=Di[22]}
N 5430 -380 5450 -380 {
lab=Di[23]}
N 5430 -360 5450 -360 {
lab=Di[24]}
N 5430 -340 5450 -340 {
lab=Di[25]}
N 5430 -320 5450 -320 {
lab=Di[26]}
N 5430 -300 5450 -300 {
lab=Di[27]}
N 5430 -280 5450 -280 {
lab=Di[28]}
N 5430 -260 5450 -260 {
lab=Di[29]}
N 5430 -240 5450 -240 {
lab=Di[30]}
N 5430 -220 5450 -220 {
lab=Di[31]}
N 5520 -900 5520 -880 {
lab=CLK_buf}
N 5540 -900 5540 -880 {
lab=SEL[31]}
N 5560 -900 5560 -880 {
lab=we0_buf}
N 5580 -900 5580 -880 {
lab=we1_buf}
N 5600 -900 5600 -880 {
lab=we2_buf}
N 5620 -900 5620 -880 {
lab=we3_buf}
N 5650 -900 5650 -880 {
lab=VDD}
N 5670 -900 5670 -880 {
lab=VSS}
N 4910 -840 4930 -840 {
lab=di0_buf}
N 4910 -820 4930 -820 {
lab=di1_buf}
N 4910 -800 4930 -800 {
lab=di2_buf}
N 4910 -780 4930 -780 {
lab=di3_buf}
N 4910 -760 4930 -760 {
lab=di4_buf}
N 4910 -740 4930 -740 {
lab=di5_buf}
N 4910 -720 4930 -720 {
lab=di6_buf}
N 4910 -700 4930 -700 {
lab=di7_buf}
N 4910 -680 4930 -680 {
lab=di8_buf}
N 4910 -660 4930 -660 {
lab=di9_buf}
N 4910 -640 4930 -640 {
lab=di10_buf}
N 4910 -620 4930 -620 {
lab=di11_buf}
N 4910 -600 4930 -600 {
lab=di12_buf}
N 4910 -580 4930 -580 {
lab=di13_buf}
N 4910 -560 4930 -560 {
lab=di14_buf}
N 4910 -540 4930 -540 {
lab=di15_buf}
N 4910 -520 4930 -520 {
lab=di16_buf}
N 4910 -500 4930 -500 {
lab=Di[17]}
N 4910 -480 4930 -480 {
lab=Di[18]}
N 4910 -460 4930 -460 {
lab=Di[19]}
N 4910 -440 4930 -440 {
lab=Di[20]}
N 4910 -420 4930 -420 {
lab=Di[21]}
N 4910 -400 4930 -400 {
lab=Di[22]}
N 4910 -380 4930 -380 {
lab=Di[23]}
N 4910 -360 4930 -360 {
lab=Di[24]}
N 4910 -340 4930 -340 {
lab=Di[25]}
N 4910 -320 4930 -320 {
lab=Di[26]}
N 4910 -300 4930 -300 {
lab=Di[27]}
N 4910 -280 4930 -280 {
lab=Di[28]}
N 4910 -260 4930 -260 {
lab=Di[29]}
N 4910 -240 4930 -240 {
lab=Di[30]}
N 4910 -220 4930 -220 {
lab=Di[31]}
N 5000 -900 5000 -880 {
lab=CLK_buf}
N 5020 -900 5020 -880 {
lab=SEL[30]}
N 5040 -900 5040 -880 {
lab=we0_buf}
N 5060 -900 5060 -880 {
lab=we1_buf}
N 5080 -900 5080 -880 {
lab=we2_buf}
N 5100 -900 5100 -880 {
lab=we3_buf}
N 5130 -900 5130 -880 {
lab=VDD}
N 5150 -900 5150 -880 {
lab=VSS}
N 4370 -840 4390 -840 {
lab=di0_buf}
N 4370 -820 4390 -820 {
lab=di1_buf}
N 4370 -800 4390 -800 {
lab=di2_buf}
N 4370 -780 4390 -780 {
lab=di3_buf}
N 4370 -760 4390 -760 {
lab=di4_buf}
N 4370 -740 4390 -740 {
lab=di5_buf}
N 4370 -720 4390 -720 {
lab=di6_buf}
N 4370 -700 4390 -700 {
lab=di7_buf}
N 4370 -680 4390 -680 {
lab=di8_buf}
N 4370 -660 4390 -660 {
lab=di9_buf}
N 4370 -640 4390 -640 {
lab=di10_buf}
N 4370 -620 4390 -620 {
lab=di11_buf}
N 4370 -600 4390 -600 {
lab=di12_buf}
N 4370 -580 4390 -580 {
lab=di13_buf}
N 4370 -560 4390 -560 {
lab=di14_buf}
N 4370 -540 4390 -540 {
lab=di15_buf}
N 4370 -520 4390 -520 {
lab=di16_buf}
N 4370 -500 4390 -500 {
lab=Di[17]}
N 4370 -480 4390 -480 {
lab=Di[18]}
N 4370 -460 4390 -460 {
lab=Di[19]}
N 4370 -440 4390 -440 {
lab=Di[20]}
N 4370 -420 4390 -420 {
lab=Di[21]}
N 4370 -400 4390 -400 {
lab=Di[22]}
N 4370 -380 4390 -380 {
lab=Di[23]}
N 4370 -360 4390 -360 {
lab=Di[24]}
N 4370 -340 4390 -340 {
lab=Di[25]}
N 4370 -320 4390 -320 {
lab=Di[26]}
N 4370 -300 4390 -300 {
lab=Di[27]}
N 4370 -280 4390 -280 {
lab=Di[28]}
N 4370 -260 4390 -260 {
lab=Di[29]}
N 4370 -240 4390 -240 {
lab=Di[30]}
N 4370 -220 4390 -220 {
lab=Di[31]}
N 4460 -900 4460 -880 {
lab=CLK_buf}
N 4480 -900 4480 -880 {
lab=SEL[29]}
N 4500 -900 4500 -880 {
lab=we0_buf}
N 4520 -900 4520 -880 {
lab=we1_buf}
N 4540 -900 4540 -880 {
lab=we2_buf}
N 4560 -900 4560 -880 {
lab=we3_buf}
N 4590 -900 4590 -880 {
lab=VDD}
N 4610 -900 4610 -880 {
lab=VSS}
N 3850 -840 3870 -840 {
lab=di0_buf}
N 3850 -820 3870 -820 {
lab=di1_buf}
N 3850 -800 3870 -800 {
lab=di2_buf}
N 3850 -780 3870 -780 {
lab=di3_buf}
N 3850 -760 3870 -760 {
lab=di4_buf}
N 3850 -740 3870 -740 {
lab=di5_buf}
N 3850 -720 3870 -720 {
lab=di6_buf}
N 3850 -700 3870 -700 {
lab=di7_buf}
N 3850 -680 3870 -680 {
lab=di8_buf}
N 3850 -660 3870 -660 {
lab=di9_buf}
N 3850 -640 3870 -640 {
lab=di10_buf}
N 3850 -620 3870 -620 {
lab=di11_buf}
N 3850 -600 3870 -600 {
lab=di12_buf}
N 3850 -580 3870 -580 {
lab=di13_buf}
N 3850 -560 3870 -560 {
lab=di14_buf}
N 3850 -540 3870 -540 {
lab=di15_buf}
N 3850 -520 3870 -520 {
lab=di16_buf}
N 3850 -500 3870 -500 {
lab=Di[17]}
N 3850 -480 3870 -480 {
lab=Di[18]}
N 3850 -460 3870 -460 {
lab=Di[19]}
N 3850 -440 3870 -440 {
lab=Di[20]}
N 3850 -420 3870 -420 {
lab=Di[21]}
N 3850 -400 3870 -400 {
lab=Di[22]}
N 3850 -380 3870 -380 {
lab=Di[23]}
N 3850 -360 3870 -360 {
lab=Di[24]}
N 3850 -340 3870 -340 {
lab=Di[25]}
N 3850 -320 3870 -320 {
lab=Di[26]}
N 3850 -300 3870 -300 {
lab=Di[27]}
N 3850 -280 3870 -280 {
lab=Di[28]}
N 3850 -260 3870 -260 {
lab=Di[29]}
N 3850 -240 3870 -240 {
lab=Di[30]}
N 3850 -220 3870 -220 {
lab=Di[31]}
N 3940 -900 3940 -880 {
lab=CLK_buf}
N 3960 -900 3960 -880 {
lab=SEL[28]}
N 3980 -900 3980 -880 {
lab=we0_buf}
N 4000 -900 4000 -880 {
lab=we1_buf}
N 4020 -900 4020 -880 {
lab=we2_buf}
N 4040 -900 4040 -880 {
lab=we3_buf}
N 4070 -900 4070 -880 {
lab=VDD}
N 4090 -900 4090 -880 {
lab=VSS}
N 3330 -840 3350 -840 {
lab=di0_buf}
N 3330 -820 3350 -820 {
lab=di1_buf}
N 3330 -800 3350 -800 {
lab=di2_buf}
N 3330 -780 3350 -780 {
lab=di3_buf}
N 3330 -760 3350 -760 {
lab=di4_buf}
N 3330 -740 3350 -740 {
lab=di5_buf}
N 3330 -720 3350 -720 {
lab=di6_buf}
N 3330 -700 3350 -700 {
lab=di7_buf}
N 3330 -680 3350 -680 {
lab=di8_buf}
N 3330 -660 3350 -660 {
lab=di9_buf}
N 3330 -640 3350 -640 {
lab=di10_buf}
N 3330 -620 3350 -620 {
lab=di11_buf}
N 3330 -600 3350 -600 {
lab=di12_buf}
N 3330 -580 3350 -580 {
lab=di13_buf}
N 3330 -560 3350 -560 {
lab=di14_buf}
N 3330 -540 3350 -540 {
lab=di15_buf}
N 3330 -520 3350 -520 {
lab=di16_buf}
N 3330 -500 3350 -500 {
lab=Di[17]}
N 3330 -480 3350 -480 {
lab=Di[18]}
N 3330 -460 3350 -460 {
lab=Di[19]}
N 3330 -440 3350 -440 {
lab=Di[20]}
N 3330 -420 3350 -420 {
lab=Di[21]}
N 3330 -400 3350 -400 {
lab=Di[22]}
N 3330 -380 3350 -380 {
lab=Di[23]}
N 3330 -360 3350 -360 {
lab=Di[24]}
N 3330 -340 3350 -340 {
lab=Di[25]}
N 3330 -320 3350 -320 {
lab=Di[26]}
N 3330 -300 3350 -300 {
lab=Di[27]}
N 3330 -280 3350 -280 {
lab=Di[28]}
N 3330 -260 3350 -260 {
lab=Di[29]}
N 3330 -240 3350 -240 {
lab=Di[30]}
N 3330 -220 3350 -220 {
lab=Di[31]}
N 3420 -900 3420 -880 {
lab=CLK_buf}
N 3440 -900 3440 -880 {
lab=SEL[27]}
N 3460 -900 3460 -880 {
lab=we0_buf}
N 3480 -900 3480 -880 {
lab=we1_buf}
N 3500 -900 3500 -880 {
lab=we2_buf}
N 3520 -900 3520 -880 {
lab=we3_buf}
N 3550 -900 3550 -880 {
lab=VDD}
N 3570 -900 3570 -880 {
lab=VSS}
N 2810 -840 2830 -840 {
lab=di0_buf}
N 2810 -820 2830 -820 {
lab=di1_buf}
N 2810 -800 2830 -800 {
lab=di2_buf}
N 2810 -780 2830 -780 {
lab=di3_buf}
N 2810 -760 2830 -760 {
lab=di4_buf}
N 2810 -740 2830 -740 {
lab=di5_buf}
N 2810 -720 2830 -720 {
lab=di6_buf}
N 2810 -700 2830 -700 {
lab=di7_buf}
N 2810 -680 2830 -680 {
lab=di8_buf}
N 2810 -660 2830 -660 {
lab=di9_buf}
N 2810 -640 2830 -640 {
lab=di10_buf}
N 2810 -620 2830 -620 {
lab=di11_buf}
N 2810 -600 2830 -600 {
lab=di12_buf}
N 2810 -580 2830 -580 {
lab=di13_buf}
N 2810 -560 2830 -560 {
lab=di14_buf}
N 2810 -540 2830 -540 {
lab=di15_buf}
N 2810 -520 2830 -520 {
lab=di16_buf}
N 2810 -500 2830 -500 {
lab=Di[17]}
N 2810 -480 2830 -480 {
lab=Di[18]}
N 2810 -460 2830 -460 {
lab=Di[19]}
N 2810 -440 2830 -440 {
lab=Di[20]}
N 2810 -420 2830 -420 {
lab=Di[21]}
N 2810 -400 2830 -400 {
lab=Di[22]}
N 2810 -380 2830 -380 {
lab=Di[23]}
N 2810 -360 2830 -360 {
lab=Di[24]}
N 2810 -340 2830 -340 {
lab=Di[25]}
N 2810 -320 2830 -320 {
lab=Di[26]}
N 2810 -300 2830 -300 {
lab=Di[27]}
N 2810 -280 2830 -280 {
lab=Di[28]}
N 2810 -260 2830 -260 {
lab=Di[29]}
N 2810 -240 2830 -240 {
lab=Di[30]}
N 2810 -220 2830 -220 {
lab=Di[31]}
N 2900 -900 2900 -880 {
lab=CLK_buf}
N 2920 -900 2920 -880 {
lab=SEL[26]}
N 2940 -900 2940 -880 {
lab=we0_buf}
N 2960 -900 2960 -880 {
lab=we1_buf}
N 2980 -900 2980 -880 {
lab=we2_buf}
N 3000 -900 3000 -880 {
lab=we3_buf}
N 3030 -900 3030 -880 {
lab=VDD}
N 3050 -900 3050 -880 {
lab=VSS}
N 2270 -840 2290 -840 {
lab=di0_buf}
N 2270 -820 2290 -820 {
lab=di1_buf}
N 2270 -800 2290 -800 {
lab=di2_buf}
N 2270 -780 2290 -780 {
lab=di3_buf}
N 2270 -760 2290 -760 {
lab=di4_buf}
N 2270 -740 2290 -740 {
lab=di5_buf}
N 2270 -720 2290 -720 {
lab=di6_buf}
N 2270 -700 2290 -700 {
lab=di7_buf}
N 2270 -680 2290 -680 {
lab=di8_buf}
N 2270 -660 2290 -660 {
lab=di9_buf}
N 2270 -640 2290 -640 {
lab=di10_buf}
N 2270 -620 2290 -620 {
lab=di11_buf}
N 2270 -600 2290 -600 {
lab=di12_buf}
N 2270 -580 2290 -580 {
lab=di13_buf}
N 2270 -560 2290 -560 {
lab=di14_buf}
N 2270 -540 2290 -540 {
lab=di15_buf}
N 2270 -520 2290 -520 {
lab=di16_buf}
N 2270 -500 2290 -500 {
lab=Di[17]}
N 2270 -480 2290 -480 {
lab=Di[18]}
N 2270 -460 2290 -460 {
lab=Di[19]}
N 2270 -440 2290 -440 {
lab=Di[20]}
N 2270 -420 2290 -420 {
lab=Di[21]}
N 2270 -400 2290 -400 {
lab=Di[22]}
N 2270 -380 2290 -380 {
lab=Di[23]}
N 2270 -360 2290 -360 {
lab=Di[24]}
N 2270 -340 2290 -340 {
lab=Di[25]}
N 2270 -320 2290 -320 {
lab=Di[26]}
N 2270 -300 2290 -300 {
lab=Di[27]}
N 2270 -280 2290 -280 {
lab=Di[28]}
N 2270 -260 2290 -260 {
lab=Di[29]}
N 2270 -240 2290 -240 {
lab=Di[30]}
N 2270 -220 2290 -220 {
lab=Di[31]}
N 2360 -900 2360 -880 {
lab=CLK_buf}
N 2380 -900 2380 -880 {
lab=SEL[25]}
N 2400 -900 2400 -880 {
lab=we0_buf}
N 2420 -900 2420 -880 {
lab=we1_buf}
N 2440 -900 2440 -880 {
lab=we2_buf}
N 2460 -900 2460 -880 {
lab=we3_buf}
N 2490 -900 2490 -880 {
lab=VDD}
N 2510 -900 2510 -880 {
lab=VSS}
N 1750 -840 1770 -840 {
lab=di0_buf}
N 1750 -820 1770 -820 {
lab=di1_buf}
N 1750 -800 1770 -800 {
lab=di2_buf}
N 1750 -780 1770 -780 {
lab=di3_buf}
N 1750 -760 1770 -760 {
lab=di4_buf}
N 1750 -740 1770 -740 {
lab=di5_buf}
N 1750 -720 1770 -720 {
lab=di6_buf}
N 1750 -700 1770 -700 {
lab=di7_buf}
N 1750 -680 1770 -680 {
lab=di8_buf}
N 1750 -660 1770 -660 {
lab=di9_buf}
N 1750 -640 1770 -640 {
lab=di10_buf}
N 1750 -620 1770 -620 {
lab=di11_buf}
N 1750 -600 1770 -600 {
lab=di12_buf}
N 1750 -580 1770 -580 {
lab=di13_buf}
N 1750 -560 1770 -560 {
lab=di14_buf}
N 1750 -540 1770 -540 {
lab=di15_buf}
N 1750 -520 1770 -520 {
lab=di16_buf}
N 1750 -500 1770 -500 {
lab=Di[17]}
N 1750 -480 1770 -480 {
lab=Di[18]}
N 1750 -460 1770 -460 {
lab=Di[19]}
N 1750 -440 1770 -440 {
lab=Di[20]}
N 1750 -420 1770 -420 {
lab=Di[21]}
N 1750 -400 1770 -400 {
lab=Di[22]}
N 1750 -380 1770 -380 {
lab=Di[23]}
N 1750 -360 1770 -360 {
lab=Di[24]}
N 1750 -340 1770 -340 {
lab=Di[25]}
N 1750 -320 1770 -320 {
lab=Di[26]}
N 1750 -300 1770 -300 {
lab=Di[27]}
N 1750 -280 1770 -280 {
lab=Di[28]}
N 1750 -260 1770 -260 {
lab=Di[29]}
N 1750 -240 1770 -240 {
lab=Di[30]}
N 1750 -220 1770 -220 {
lab=Di[31]}
N 1840 -900 1840 -880 {
lab=CLK_buf}
N 1860 -900 1860 -880 {
lab=SEL[24]}
N 1880 -900 1880 -880 {
lab=we0_buf}
N 1900 -900 1900 -880 {
lab=we1_buf}
N 1920 -900 1920 -880 {
lab=we2_buf}
N 1940 -900 1940 -880 {
lab=we3_buf}
N 1970 -900 1970 -880 {
lab=VDD}
N 1990 -900 1990 -880 {
lab=VSS}
N 70 -3870 70 -3860 {
lab=VDD}
N 70 -3780 70 -3770 {
lab=VSS}
N 520 -3820 540 -3820 {
lab=CLK_buf}
N 190 -3820 200 -3820 {
lab=#net37}
N 260 -3870 260 -3860 {
lab=VDD}
N 260 -3780 260 -3770 {
lab=VSS}
N -20 -3820 0 -3820 {
lab=#net38}
N -190 -3820 -180 -3820 {
lab=CLK}
N -120 -3870 -120 -3860 {
lab=VDD}
N -120 -3780 -120 -3770 {
lab=VSS}
N 540 -3820 560 -3820 {lab=CLK_buf}
N -40 -3820 -20 -3820 {
lab=#net38}
N 370 -3820 380 -3820 {
lab=#net51}
N 440 -3870 440 -3860 {
lab=VDD}
N 440 -3780 440 -3770 {
lab=VSS}
N 340 -3820 370 -3820 {
lab=#net51}
N 0 -80 20 -80 {
lab=Di28}
N 0 -210 20 -210 {
lab=Di24}
N 0 -340 20 -340 {
lab=Di20}
N 0 -470 20 -470 {
lab=Di16}
N 0 -600 20 -600 {
lab=Di12}
N 0 -730 20 -730 {
lab=Di8}
N -0 -860 20 -860 {
lab=Di4}
N 0 -990 20 -990 {
lab=Di0}
N 560 -990 580 -990 {
lab=#net52}
N 480 -1030 640 -1030 {
lab=VDD}
N 480 -950 640 -950 {
lab=VSS}
N 560 -860 580 -860 {
lab=#net53}
N 480 -900 640 -900 {
lab=VDD}
N 480 -820 640 -820 {
lab=VSS}
N 560 -730 580 -730 {
lab=#net54}
N 480 -770 640 -770 {
lab=VDD}
N 480 -690 640 -690 {
lab=VSS}
N 560 -600 580 -600 {
lab=#net55}
N 480 -640 640 -640 {
lab=VDD}
N 480 -560 640 -560 {
lab=VSS}
N 560 -470 580 -470 {
lab=#net56}
N 480 -510 640 -510 {
lab=VDD}
N 480 -430 640 -430 {
lab=VSS}
N 560 -340 580 -340 {
lab=#net57}
N 480 -380 640 -380 {
lab=VDD}
N 480 -300 640 -300 {
lab=VSS}
N 560 -210 580 -210 {
lab=#net58}
N 480 -250 640 -250 {
lab=VDD}
N 480 -170 640 -170 {
lab=VSS}
N 560 -80 580 -80 {
lab=#net59}
N 480 -120 640 -120 {
lab=VDD}
N 480 -40 640 -40 {
lab=VSS}
N 960 -990 980 -990 {
lab=#net60}
N 880 -1030 1040 -1030 {
lab=VDD}
N 880 -950 1040 -950 {
lab=VSS}
N 960 -860 980 -860 {
lab=#net61}
N 880 -900 1040 -900 {
lab=VDD}
N 880 -820 1040 -820 {
lab=VSS}
N 960 -730 980 -730 {
lab=#net62}
N 880 -770 1040 -770 {
lab=VDD}
N 880 -690 1040 -690 {
lab=VSS}
N 960 -600 980 -600 {
lab=#net63}
N 880 -640 1040 -640 {
lab=VDD}
N 880 -560 1040 -560 {
lab=VSS}
N 960 -470 980 -470 {
lab=#net64}
N 880 -510 1040 -510 {
lab=VDD}
N 880 -430 1040 -430 {
lab=VSS}
N 960 -340 980 -340 {
lab=#net65}
N 880 -380 1040 -380 {
lab=VDD}
N 880 -300 1040 -300 {
lab=VSS}
N 960 -210 980 -210 {
lab=#net66}
N 880 -250 1040 -250 {
lab=VDD}
N 880 -170 1040 -170 {
lab=VSS}
N 960 -80 980 -80 {
lab=#net67}
N 880 -120 1040 -120 {
lab=VDD}
N 880 -40 1040 -40 {
lab=VSS}
N 1360 -990 1380 -990 {
lab=#net68}
N 1280 -1030 1440 -1030 {
lab=VDD}
N 1280 -950 1440 -950 {
lab=VSS}
N 1360 -860 1380 -860 {
lab=#net69}
N 1280 -900 1440 -900 {
lab=VDD}
N 1280 -820 1440 -820 {
lab=VSS}
N 1360 -730 1380 -730 {
lab=#net70}
N 1280 -770 1440 -770 {
lab=VDD}
N 1280 -690 1440 -690 {
lab=VSS}
N 1360 -600 1380 -600 {
lab=#net71}
N 1280 -640 1440 -640 {
lab=VDD}
N 1280 -560 1440 -560 {
lab=VSS}
N 1360 -470 1380 -470 {
lab=#net72}
N 1280 -510 1440 -510 {
lab=VDD}
N 1280 -430 1440 -430 {
lab=VSS}
N 1360 -340 1380 -340 {
lab=#net73}
N 1280 -380 1440 -380 {
lab=VDD}
N 1280 -300 1440 -300 {
lab=VSS}
N 1360 -210 1380 -210 {
lab=#net74}
N 1280 -250 1440 -250 {
lab=VDD}
N 1280 -170 1440 -170 {
lab=VSS}
N 1360 -80 1380 -80 {
lab=#net75}
N 1280 -120 1440 -120 {
lab=VDD}
N 1280 -40 1440 -40 {
lab=VSS}
N 800 -990 820 -990 {
lab=Di2}
N 800 -860 820 -860 {
lab=Di6}
N 800 -730 820 -730 {
lab=Di10}
N 800 -600 820 -600 {
lab=Di14}
N 800 -470 820 -470 {
lab=Di18}
N 800 -340 820 -340 {
lab=Di22}
N 800 -210 820 -210 {
lab=Di26}
N 800 -80 820 -80 {
lab=Di30}
N 1200 -990 1220 -990 {
lab=Di3}
N 1200 -860 1220 -860 {
lab=Di7}
N 1200 -730 1220 -730 {
lab=Di11}
N 1200 -600 1220 -600 {
lab=Di15}
N 1200 -470 1220 -470 {
lab=Di19}
N 1200 -340 1220 -340 {
lab=Di23}
N 1200 -210 1220 -210 {
lab=Di27}
N 1200 -80 1220 -80 {
lab=Di31}
N 400 -990 420 -990 {
lab=Di1}
N 400 -860 420 -860 {
lab=Di5}
N 400 -730 420 -730 {
lab=Di9}
N 400 -600 420 -600 {
lab=Di13}
N 400 -470 420 -470 {
lab=Di17}
N 400 -340 420 -340 {
lab=Di21}
N 400 -210 420 -210 {
lab=Di25}
N 400 -80 420 -80 {
lab=Di29}
N 2580 -3590 2600 -3590 {
lab=Do0}
N 2580 -3570 2600 -3570 {
lab=Do1}
N 2580 -3550 2600 -3550 {
lab=Do2}
N 2580 -3530 2600 -3530 {
lab=Do3}
N 2580 -3510 2600 -3510 {
lab=Do4}
N 2580 -3490 2600 -3490 {
lab=Do5}
N 2580 -3470 2600 -3470 {
lab=Do6}
N 2580 -3450 2600 -3450 {
lab=Do7}
N 2580 -3430 2600 -3430 {
lab=Do8}
N 2580 -3410 2600 -3410 {
lab=Do9}
N 2580 -3390 2600 -3390 {
lab=Do10}
N 2580 -3370 2600 -3370 {
lab=Do11}
N 2580 -3350 2600 -3350 {
lab=Do12}
N 2580 -3330 2600 -3330 {
lab=Do13}
N 2580 -3310 2600 -3310 {
lab=Do14}
N 2580 -3290 2600 -3290 {
lab=Do15}
N 2580 -3270 2600 -3270 {
lab=Do16}
N 2580 -3250 2600 -3250 {
lab=Do17}
N 2580 -3230 2600 -3230 {
lab=Do18}
N 2580 -3210 2600 -3210 {
lab=Do19}
N 2580 -3190 2600 -3190 {
lab=Do20}
N 2580 -3170 2600 -3170 {
lab=Do21}
N 2580 -3150 2600 -3150 {
lab=Do22}
N 2580 -3130 2600 -3130 {
lab=Do23}
N 2580 -3110 2600 -3110 {
lab=Do24}
N 2580 -3090 2600 -3090 {
lab=Do25}
N 2580 -3070 2600 -3070 {
lab=Do26}
N 2580 -3050 2600 -3050 {
lab=Do27}
N 2580 -3030 2600 -3030 {
lab=Do28}
N 2580 -3010 2600 -3010 {
lab=Do29}
N 2580 -2990 2600 -2990 {
lab=Do30}
N 2580 -2970 2600 -2970 {
lab=Do31}
N 3120 -3590 3140 -3590 {
lab=Do0}
N 3120 -3570 3140 -3570 {
lab=Do1}
N 3120 -3550 3140 -3550 {
lab=Do2}
N 3120 -3530 3140 -3530 {
lab=Do3}
N 3120 -3510 3140 -3510 {
lab=Do4}
N 3120 -3490 3140 -3490 {
lab=Do5}
N 3120 -3470 3140 -3470 {
lab=Do6}
N 3120 -3450 3140 -3450 {
lab=Do7}
N 3120 -3430 3140 -3430 {
lab=Do8}
N 3120 -3410 3140 -3410 {
lab=Do9}
N 3120 -3390 3140 -3390 {
lab=Do10}
N 3120 -3370 3140 -3370 {
lab=Do11}
N 3120 -3350 3140 -3350 {
lab=Do12}
N 3120 -3330 3140 -3330 {
lab=Do13}
N 3120 -3310 3140 -3310 {
lab=Do14}
N 3120 -3290 3140 -3290 {
lab=Do15}
N 3120 -3270 3140 -3270 {
lab=Do16}
N 3120 -3250 3140 -3250 {
lab=Do17}
N 3120 -3230 3140 -3230 {
lab=Do18}
N 3120 -3210 3140 -3210 {
lab=Do19}
N 3120 -3190 3140 -3190 {
lab=Do20}
N 3120 -3170 3140 -3170 {
lab=Do21}
N 3120 -3150 3140 -3150 {
lab=Do22}
N 3120 -3130 3140 -3130 {
lab=Do23}
N 3120 -3110 3140 -3110 {
lab=Do24}
N 3120 -3090 3140 -3090 {
lab=Do25}
N 3120 -3070 3140 -3070 {
lab=Do26}
N 3120 -3050 3140 -3050 {
lab=Do27}
N 3120 -3030 3140 -3030 {
lab=Do28}
N 3120 -3010 3140 -3010 {
lab=Do29}
N 3120 -2990 3140 -2990 {
lab=Do30}
N 3120 -2970 3140 -2970 {
lab=Do31}
N 3640 -3590 3660 -3590 {
lab=Do0}
N 3640 -3570 3660 -3570 {
lab=Do1}
N 3640 -3550 3660 -3550 {
lab=Do2}
N 3640 -3530 3660 -3530 {
lab=Do3}
N 3640 -3510 3660 -3510 {
lab=Do4}
N 3640 -3490 3660 -3490 {
lab=Do5}
N 3640 -3470 3660 -3470 {
lab=Do6}
N 3640 -3450 3660 -3450 {
lab=Do7}
N 3640 -3430 3660 -3430 {
lab=Do8}
N 3640 -3410 3660 -3410 {
lab=Do9}
N 3640 -3390 3660 -3390 {
lab=Do10}
N 3640 -3370 3660 -3370 {
lab=Do11}
N 3640 -3350 3660 -3350 {
lab=Do12}
N 3640 -3330 3660 -3330 {
lab=Do13}
N 3640 -3310 3660 -3310 {
lab=Do14}
N 3640 -3290 3660 -3290 {
lab=Do15}
N 3640 -3270 3660 -3270 {
lab=Do16}
N 3640 -3250 3660 -3250 {
lab=Do17}
N 3640 -3230 3660 -3230 {
lab=Do18}
N 3640 -3210 3660 -3210 {
lab=Do19}
N 3640 -3190 3660 -3190 {
lab=Do20}
N 3640 -3170 3660 -3170 {
lab=Do21}
N 3640 -3150 3660 -3150 {
lab=Do22}
N 3640 -3130 3660 -3130 {
lab=Do23}
N 3640 -3110 3660 -3110 {
lab=Do24}
N 3640 -3090 3660 -3090 {
lab=Do25}
N 3640 -3070 3660 -3070 {
lab=Do26}
N 3640 -3050 3660 -3050 {
lab=Do27}
N 3640 -3030 3660 -3030 {
lab=Do28}
N 3640 -3010 3660 -3010 {
lab=Do29}
N 3640 -2990 3660 -2990 {
lab=Do30}
N 3640 -2970 3660 -2970 {
lab=Do31}
N 4160 -3590 4180 -3590 {
lab=Do0}
N 4160 -3570 4180 -3570 {
lab=Do1}
N 4160 -3550 4180 -3550 {
lab=Do2}
N 4160 -3530 4180 -3530 {
lab=Do3}
N 4160 -3510 4180 -3510 {
lab=Do4}
N 4160 -3490 4180 -3490 {
lab=Do5}
N 4160 -3470 4180 -3470 {
lab=Do6}
N 4160 -3450 4180 -3450 {
lab=Do7}
N 4160 -3430 4180 -3430 {
lab=Do8}
N 4160 -3410 4180 -3410 {
lab=Do9}
N 4160 -3390 4180 -3390 {
lab=Do10}
N 4160 -3370 4180 -3370 {
lab=Do11}
N 4160 -3350 4180 -3350 {
lab=Do12}
N 4160 -3330 4180 -3330 {
lab=Do13}
N 4160 -3310 4180 -3310 {
lab=Do14}
N 4160 -3290 4180 -3290 {
lab=Do15}
N 4160 -3270 4180 -3270 {
lab=Do16}
N 4160 -3250 4180 -3250 {
lab=Do17}
N 4160 -3230 4180 -3230 {
lab=Do18}
N 4160 -3210 4180 -3210 {
lab=Do19}
N 4160 -3190 4180 -3190 {
lab=Do20}
N 4160 -3170 4180 -3170 {
lab=Do21}
N 4160 -3150 4180 -3150 {
lab=Do22}
N 4160 -3130 4180 -3130 {
lab=Do23}
N 4160 -3110 4180 -3110 {
lab=Do24}
N 4160 -3090 4180 -3090 {
lab=Do25}
N 4160 -3070 4180 -3070 {
lab=Do26}
N 4160 -3050 4180 -3050 {
lab=Do27}
N 4160 -3030 4180 -3030 {
lab=Do28}
N 4160 -3010 4180 -3010 {
lab=Do29}
N 4160 -2990 4180 -2990 {
lab=Do30}
N 4160 -2970 4180 -2970 {
lab=Do31}
N 4680 -3590 4700 -3590 {
lab=Do0}
N 4680 -3570 4700 -3570 {
lab=Do1}
N 4680 -3550 4700 -3550 {
lab=Do2}
N 4680 -3530 4700 -3530 {
lab=Do3}
N 4680 -3510 4700 -3510 {
lab=Do4}
N 4680 -3490 4700 -3490 {
lab=Do5}
N 4680 -3470 4700 -3470 {
lab=Do6}
N 4680 -3450 4700 -3450 {
lab=Do7}
N 4680 -3430 4700 -3430 {
lab=Do8}
N 4680 -3410 4700 -3410 {
lab=Do9}
N 4680 -3390 4700 -3390 {
lab=Do10}
N 4680 -3370 4700 -3370 {
lab=Do11}
N 4680 -3350 4700 -3350 {
lab=Do12}
N 4680 -3330 4700 -3330 {
lab=Do13}
N 4680 -3310 4700 -3310 {
lab=Do14}
N 4680 -3290 4700 -3290 {
lab=Do15}
N 4680 -3270 4700 -3270 {
lab=Do16}
N 4680 -3250 4700 -3250 {
lab=Do17}
N 4680 -3230 4700 -3230 {
lab=Do18}
N 4680 -3210 4700 -3210 {
lab=Do19}
N 4680 -3190 4700 -3190 {
lab=Do20}
N 4680 -3170 4700 -3170 {
lab=Do21}
N 4680 -3150 4700 -3150 {
lab=Do22}
N 4680 -3130 4700 -3130 {
lab=Do23}
N 4680 -3110 4700 -3110 {
lab=Do24}
N 4680 -3090 4700 -3090 {
lab=Do25}
N 4680 -3070 4700 -3070 {
lab=Do26}
N 4680 -3050 4700 -3050 {
lab=Do27}
N 4680 -3030 4700 -3030 {
lab=Do28}
N 4680 -3010 4700 -3010 {
lab=Do29}
N 4680 -2990 4700 -2990 {
lab=Do30}
N 4680 -2970 4700 -2970 {
lab=Do31}
N 5220 -3590 5240 -3590 {
lab=Do0}
N 5220 -3570 5240 -3570 {
lab=Do1}
N 5220 -3550 5240 -3550 {
lab=Do2}
N 5220 -3530 5240 -3530 {
lab=Do3}
N 5220 -3510 5240 -3510 {
lab=Do4}
N 5220 -3490 5240 -3490 {
lab=Do5}
N 5220 -3470 5240 -3470 {
lab=Do6}
N 5220 -3450 5240 -3450 {
lab=Do7}
N 5220 -3430 5240 -3430 {
lab=Do8}
N 5220 -3410 5240 -3410 {
lab=Do9}
N 5220 -3390 5240 -3390 {
lab=Do10}
N 5220 -3370 5240 -3370 {
lab=Do11}
N 5220 -3350 5240 -3350 {
lab=Do12}
N 5220 -3330 5240 -3330 {
lab=Do13}
N 5220 -3310 5240 -3310 {
lab=Do14}
N 5220 -3290 5240 -3290 {
lab=Do15}
N 5220 -3270 5240 -3270 {
lab=Do16}
N 5220 -3250 5240 -3250 {
lab=Do17}
N 5220 -3230 5240 -3230 {
lab=Do18}
N 5220 -3210 5240 -3210 {
lab=Do19}
N 5220 -3190 5240 -3190 {
lab=Do20}
N 5220 -3170 5240 -3170 {
lab=Do21}
N 5220 -3150 5240 -3150 {
lab=Do22}
N 5220 -3130 5240 -3130 {
lab=Do23}
N 5220 -3110 5240 -3110 {
lab=Do24}
N 5220 -3090 5240 -3090 {
lab=Do25}
N 5220 -3070 5240 -3070 {
lab=Do26}
N 5220 -3050 5240 -3050 {
lab=Do27}
N 5220 -3030 5240 -3030 {
lab=Do28}
N 5220 -3010 5240 -3010 {
lab=Do29}
N 5220 -2990 5240 -2990 {
lab=Do30}
N 5220 -2970 5240 -2970 {
lab=Do31}
N 5740 -3590 5760 -3590 {
lab=Do0}
N 5740 -3570 5760 -3570 {
lab=Do1}
N 5740 -3550 5760 -3550 {
lab=Do2}
N 5740 -3530 5760 -3530 {
lab=Do3}
N 5740 -3510 5760 -3510 {
lab=Do4}
N 5740 -3490 5760 -3490 {
lab=Do5}
N 5740 -3470 5760 -3470 {
lab=Do6}
N 5740 -3450 5760 -3450 {
lab=Do7}
N 5740 -3430 5760 -3430 {
lab=Do8}
N 5740 -3410 5760 -3410 {
lab=Do9}
N 5740 -3390 5760 -3390 {
lab=Do10}
N 5740 -3370 5760 -3370 {
lab=Do11}
N 5740 -3350 5760 -3350 {
lab=Do12}
N 5740 -3330 5760 -3330 {
lab=Do13}
N 5740 -3310 5760 -3310 {
lab=Do14}
N 5740 -3290 5760 -3290 {
lab=Do15}
N 5740 -3270 5760 -3270 {
lab=Do16}
N 5740 -3250 5760 -3250 {
lab=Do17}
N 5740 -3230 5760 -3230 {
lab=Do18}
N 5740 -3210 5760 -3210 {
lab=Do19}
N 5740 -3190 5760 -3190 {
lab=Do20}
N 5740 -3170 5760 -3170 {
lab=Do21}
N 5740 -3150 5760 -3150 {
lab=Do22}
N 5740 -3130 5760 -3130 {
lab=Do23}
N 5740 -3110 5760 -3110 {
lab=Do24}
N 5740 -3090 5760 -3090 {
lab=Do25}
N 5740 -3070 5760 -3070 {
lab=Do26}
N 5740 -3050 5760 -3050 {
lab=Do27}
N 5740 -3030 5760 -3030 {
lab=Do28}
N 5740 -3010 5760 -3010 {
lab=Do29}
N 5740 -2990 5760 -2990 {
lab=Do30}
N 5740 -2970 5760 -2970 {
lab=Do31}
N 2060 -2690 2080 -2690 {
lab=Do0}
N 2060 -2670 2080 -2670 {
lab=Do1}
N 2060 -2650 2080 -2650 {
lab=Do2}
N 2060 -2630 2080 -2630 {
lab=Do3}
N 2060 -2610 2080 -2610 {
lab=Do4}
N 2060 -2590 2080 -2590 {
lab=Do5}
N 2060 -2570 2080 -2570 {
lab=Do6}
N 2060 -2550 2080 -2550 {
lab=Do7}
N 2060 -2530 2080 -2530 {
lab=Do8}
N 2060 -2510 2080 -2510 {
lab=Do9}
N 2060 -2490 2080 -2490 {
lab=Do10}
N 2060 -2470 2080 -2470 {
lab=Do11}
N 2060 -2450 2080 -2450 {
lab=Do12}
N 2060 -2430 2080 -2430 {
lab=Do13}
N 2060 -2410 2080 -2410 {
lab=Do14}
N 2060 -2390 2080 -2390 {
lab=Do15}
N 2060 -2370 2080 -2370 {
lab=Do16}
N 2060 -2350 2080 -2350 {
lab=Do17}
N 2060 -2330 2080 -2330 {
lab=Do18}
N 2060 -2310 2080 -2310 {
lab=Do19}
N 2060 -2290 2080 -2290 {
lab=Do20}
N 2060 -2270 2080 -2270 {
lab=Do21}
N 2060 -2250 2080 -2250 {
lab=Do22}
N 2060 -2230 2080 -2230 {
lab=Do23}
N 2060 -2210 2080 -2210 {
lab=Do24}
N 2060 -2190 2080 -2190 {
lab=Do25}
N 2060 -2170 2080 -2170 {
lab=Do26}
N 2060 -2150 2080 -2150 {
lab=Do27}
N 2060 -2130 2080 -2130 {
lab=Do28}
N 2060 -2110 2080 -2110 {
lab=Do29}
N 2060 -2090 2080 -2090 {
lab=Do30}
N 2060 -2070 2080 -2070 {
lab=Do31}
N 2070 -1740 2090 -1740 {
lab=Do0}
N 2070 -1720 2090 -1720 {
lab=Do1}
N 2070 -1700 2090 -1700 {
lab=Do2}
N 2070 -1680 2090 -1680 {
lab=Do3}
N 2070 -1660 2090 -1660 {
lab=Do4}
N 2070 -1640 2090 -1640 {
lab=Do5}
N 2070 -1620 2090 -1620 {
lab=Do6}
N 2070 -1600 2090 -1600 {
lab=Do7}
N 2070 -1580 2090 -1580 {
lab=Do8}
N 2070 -1560 2090 -1560 {
lab=Do9}
N 2070 -1540 2090 -1540 {
lab=Do10}
N 2070 -1520 2090 -1520 {
lab=Do11}
N 2070 -1500 2090 -1500 {
lab=Do12}
N 2070 -1480 2090 -1480 {
lab=Do13}
N 2070 -1460 2090 -1460 {
lab=Do14}
N 2070 -1440 2090 -1440 {
lab=Do15}
N 2070 -1420 2090 -1420 {
lab=Do16}
N 2070 -1400 2090 -1400 {
lab=Do17}
N 2070 -1380 2090 -1380 {
lab=Do18}
N 2070 -1360 2090 -1360 {
lab=Do19}
N 2070 -1340 2090 -1340 {
lab=Do20}
N 2070 -1320 2090 -1320 {
lab=Do21}
N 2070 -1300 2090 -1300 {
lab=Do22}
N 2070 -1280 2090 -1280 {
lab=Do23}
N 2070 -1260 2090 -1260 {
lab=Do24}
N 2070 -1240 2090 -1240 {
lab=Do25}
N 2070 -1220 2090 -1220 {
lab=Do26}
N 2070 -1200 2090 -1200 {
lab=Do27}
N 2070 -1180 2090 -1180 {
lab=Do28}
N 2070 -1160 2090 -1160 {
lab=Do29}
N 2070 -1140 2090 -1140 {
lab=Do30}
N 2070 -1120 2090 -1120 {
lab=Do31}
N 2070 -840 2090 -840 {
lab=Do0}
N 2070 -820 2090 -820 {
lab=Do1}
N 2070 -800 2090 -800 {
lab=Do2}
N 2070 -780 2090 -780 {
lab=Do3}
N 2070 -760 2090 -760 {
lab=Do4}
N 2070 -740 2090 -740 {
lab=Do5}
N 2070 -720 2090 -720 {
lab=Do6}
N 2070 -700 2090 -700 {
lab=Do7}
N 2070 -680 2090 -680 {
lab=Do8}
N 2070 -660 2090 -660 {
lab=Do9}
N 2070 -640 2090 -640 {
lab=Do10}
N 2070 -620 2090 -620 {
lab=Do11}
N 2070 -600 2090 -600 {
lab=Do12}
N 2070 -580 2090 -580 {
lab=Do13}
N 2070 -560 2090 -560 {
lab=Do14}
N 2070 -540 2090 -540 {
lab=Do15}
N 2070 -520 2090 -520 {
lab=Do16}
N 2070 -500 2090 -500 {
lab=Do17}
N 2070 -480 2090 -480 {
lab=Do18}
N 2070 -460 2090 -460 {
lab=Do19}
N 2070 -440 2090 -440 {
lab=Do20}
N 2070 -420 2090 -420 {
lab=Do21}
N 2070 -400 2090 -400 {
lab=Do22}
N 2070 -380 2090 -380 {
lab=Do23}
N 2070 -360 2090 -360 {
lab=Do24}
N 2070 -340 2090 -340 {
lab=Do25}
N 2070 -320 2090 -320 {
lab=Do26}
N 2070 -300 2090 -300 {
lab=Do27}
N 2070 -280 2090 -280 {
lab=Do28}
N 2070 -260 2090 -260 {
lab=Do29}
N 2070 -240 2090 -240 {
lab=Do30}
N 2070 -220 2090 -220 {
lab=Do31}
N 2580 -2690 2600 -2690 {
lab=Do0}
N 2580 -2670 2600 -2670 {
lab=Do1}
N 2580 -2650 2600 -2650 {
lab=Do2}
N 2580 -2630 2600 -2630 {
lab=Do3}
N 2580 -2610 2600 -2610 {
lab=Do4}
N 2580 -2590 2600 -2590 {
lab=Do5}
N 2580 -2570 2600 -2570 {
lab=Do6}
N 2580 -2550 2600 -2550 {
lab=Do7}
N 2580 -2530 2600 -2530 {
lab=Do8}
N 2580 -2510 2600 -2510 {
lab=Do9}
N 2580 -2490 2600 -2490 {
lab=Do10}
N 2580 -2470 2600 -2470 {
lab=Do11}
N 2580 -2450 2600 -2450 {
lab=Do12}
N 2580 -2430 2600 -2430 {
lab=Do13}
N 2580 -2410 2600 -2410 {
lab=Do14}
N 2580 -2390 2600 -2390 {
lab=Do15}
N 2580 -2370 2600 -2370 {
lab=Do16}
N 2580 -2350 2600 -2350 {
lab=Do17}
N 2580 -2330 2600 -2330 {
lab=Do18}
N 2580 -2310 2600 -2310 {
lab=Do19}
N 2580 -2290 2600 -2290 {
lab=Do20}
N 2580 -2270 2600 -2270 {
lab=Do21}
N 2580 -2250 2600 -2250 {
lab=Do22}
N 2580 -2230 2600 -2230 {
lab=Do23}
N 2580 -2210 2600 -2210 {
lab=Do24}
N 2580 -2190 2600 -2190 {
lab=Do25}
N 2580 -2170 2600 -2170 {
lab=Do26}
N 2580 -2150 2600 -2150 {
lab=Do27}
N 2580 -2130 2600 -2130 {
lab=Do28}
N 2580 -2110 2600 -2110 {
lab=Do29}
N 2580 -2090 2600 -2090 {
lab=Do30}
N 2580 -2070 2600 -2070 {
lab=Do31}
N 2590 -1740 2610 -1740 {
lab=Do0}
N 2590 -1720 2610 -1720 {
lab=Do1}
N 2590 -1700 2610 -1700 {
lab=Do2}
N 2590 -1680 2610 -1680 {
lab=Do3}
N 2590 -1660 2610 -1660 {
lab=Do4}
N 2590 -1640 2610 -1640 {
lab=Do5}
N 2590 -1620 2610 -1620 {
lab=Do6}
N 2590 -1600 2610 -1600 {
lab=Do7}
N 2590 -1580 2610 -1580 {
lab=Do8}
N 2590 -1560 2610 -1560 {
lab=Do9}
N 2590 -1540 2610 -1540 {
lab=Do10}
N 2590 -1520 2610 -1520 {
lab=Do11}
N 2590 -1500 2610 -1500 {
lab=Do12}
N 2590 -1480 2610 -1480 {
lab=Do13}
N 2590 -1460 2610 -1460 {
lab=Do14}
N 2590 -1440 2610 -1440 {
lab=Do15}
N 2590 -1420 2610 -1420 {
lab=Do16}
N 2590 -1400 2610 -1400 {
lab=Do17}
N 2590 -1380 2610 -1380 {
lab=Do18}
N 2590 -1360 2610 -1360 {
lab=Do19}
N 2590 -1340 2610 -1340 {
lab=Do20}
N 2590 -1320 2610 -1320 {
lab=Do21}
N 2590 -1300 2610 -1300 {
lab=Do22}
N 2590 -1280 2610 -1280 {
lab=Do23}
N 2590 -1260 2610 -1260 {
lab=Do24}
N 2590 -1240 2610 -1240 {
lab=Do25}
N 2590 -1220 2610 -1220 {
lab=Do26}
N 2590 -1200 2610 -1200 {
lab=Do27}
N 2590 -1180 2610 -1180 {
lab=Do28}
N 2590 -1160 2610 -1160 {
lab=Do29}
N 2590 -1140 2610 -1140 {
lab=Do30}
N 2590 -1120 2610 -1120 {
lab=Do31}
N 2590 -840 2610 -840 {
lab=Do0}
N 2590 -820 2610 -820 {
lab=Do1}
N 2590 -800 2610 -800 {
lab=Do2}
N 2590 -780 2610 -780 {
lab=Do3}
N 2590 -760 2610 -760 {
lab=Do4}
N 2590 -740 2610 -740 {
lab=Do5}
N 2590 -720 2610 -720 {
lab=Do6}
N 2590 -700 2610 -700 {
lab=Do7}
N 2590 -680 2610 -680 {
lab=Do8}
N 2590 -660 2610 -660 {
lab=Do9}
N 2590 -640 2610 -640 {
lab=Do10}
N 2590 -620 2610 -620 {
lab=Do11}
N 2590 -600 2610 -600 {
lab=Do12}
N 2590 -580 2610 -580 {
lab=Do13}
N 2590 -560 2610 -560 {
lab=Do14}
N 2590 -540 2610 -540 {
lab=Do15}
N 2590 -520 2610 -520 {
lab=Do16}
N 2590 -500 2610 -500 {
lab=Do17}
N 2590 -480 2610 -480 {
lab=Do18}
N 2590 -460 2610 -460 {
lab=Do19}
N 2590 -440 2610 -440 {
lab=Do20}
N 2590 -420 2610 -420 {
lab=Do21}
N 2590 -400 2610 -400 {
lab=Do22}
N 2590 -380 2610 -380 {
lab=Do23}
N 2590 -360 2610 -360 {
lab=Do24}
N 2590 -340 2610 -340 {
lab=Do25}
N 2590 -320 2610 -320 {
lab=Do26}
N 2590 -300 2610 -300 {
lab=Do27}
N 2590 -280 2610 -280 {
lab=Do28}
N 2590 -260 2610 -260 {
lab=Do29}
N 2590 -240 2610 -240 {
lab=Do30}
N 2590 -220 2610 -220 {
lab=Do31}
N 3120 -2690 3140 -2690 {
lab=Do0}
N 3120 -2670 3140 -2670 {
lab=Do1}
N 3120 -2650 3140 -2650 {
lab=Do2}
N 3120 -2630 3140 -2630 {
lab=Do3}
N 3120 -2610 3140 -2610 {
lab=Do4}
N 3120 -2590 3140 -2590 {
lab=Do5}
N 3120 -2570 3140 -2570 {
lab=Do6}
N 3120 -2550 3140 -2550 {
lab=Do7}
N 3120 -2530 3140 -2530 {
lab=Do8}
N 3120 -2510 3140 -2510 {
lab=Do9}
N 3120 -2490 3140 -2490 {
lab=Do10}
N 3120 -2470 3140 -2470 {
lab=Do11}
N 3120 -2450 3140 -2450 {
lab=Do12}
N 3120 -2430 3140 -2430 {
lab=Do13}
N 3120 -2410 3140 -2410 {
lab=Do14}
N 3120 -2390 3140 -2390 {
lab=Do15}
N 3120 -2370 3140 -2370 {
lab=Do16}
N 3120 -2350 3140 -2350 {
lab=Do17}
N 3120 -2330 3140 -2330 {
lab=Do18}
N 3120 -2310 3140 -2310 {
lab=Do19}
N 3120 -2290 3140 -2290 {
lab=Do20}
N 3120 -2270 3140 -2270 {
lab=Do21}
N 3120 -2250 3140 -2250 {
lab=Do22}
N 3120 -2230 3140 -2230 {
lab=Do23}
N 3120 -2210 3140 -2210 {
lab=Do24}
N 3120 -2190 3140 -2190 {
lab=Do25}
N 3120 -2170 3140 -2170 {
lab=Do26}
N 3120 -2150 3140 -2150 {
lab=Do27}
N 3120 -2130 3140 -2130 {
lab=Do28}
N 3120 -2110 3140 -2110 {
lab=Do29}
N 3120 -2090 3140 -2090 {
lab=Do30}
N 3120 -2070 3140 -2070 {
lab=Do31}
N 3130 -1740 3150 -1740 {
lab=Do0}
N 3130 -1720 3150 -1720 {
lab=Do1}
N 3130 -1700 3150 -1700 {
lab=Do2}
N 3130 -1680 3150 -1680 {
lab=Do3}
N 3130 -1660 3150 -1660 {
lab=Do4}
N 3130 -1640 3150 -1640 {
lab=Do5}
N 3130 -1620 3150 -1620 {
lab=Do6}
N 3130 -1600 3150 -1600 {
lab=Do7}
N 3130 -1580 3150 -1580 {
lab=Do8}
N 3130 -1560 3150 -1560 {
lab=Do9}
N 3130 -1540 3150 -1540 {
lab=Do10}
N 3130 -1520 3150 -1520 {
lab=Do11}
N 3130 -1500 3150 -1500 {
lab=Do12}
N 3130 -1480 3150 -1480 {
lab=Do13}
N 3130 -1460 3150 -1460 {
lab=Do14}
N 3130 -1440 3150 -1440 {
lab=Do15}
N 3130 -1420 3150 -1420 {
lab=Do16}
N 3130 -1400 3150 -1400 {
lab=Do17}
N 3130 -1380 3150 -1380 {
lab=Do18}
N 3130 -1360 3150 -1360 {
lab=Do19}
N 3130 -1340 3150 -1340 {
lab=Do20}
N 3130 -1320 3150 -1320 {
lab=Do21}
N 3130 -1300 3150 -1300 {
lab=Do22}
N 3130 -1280 3150 -1280 {
lab=Do23}
N 3130 -1260 3150 -1260 {
lab=Do24}
N 3130 -1240 3150 -1240 {
lab=Do25}
N 3130 -1220 3150 -1220 {
lab=Do26}
N 3130 -1200 3150 -1200 {
lab=Do27}
N 3130 -1180 3150 -1180 {
lab=Do28}
N 3130 -1160 3150 -1160 {
lab=Do29}
N 3130 -1140 3150 -1140 {
lab=Do30}
N 3130 -1120 3150 -1120 {
lab=Do31}
N 3130 -840 3150 -840 {
lab=Do0}
N 3130 -820 3150 -820 {
lab=Do1}
N 3130 -800 3150 -800 {
lab=Do2}
N 3130 -780 3150 -780 {
lab=Do3}
N 3130 -760 3150 -760 {
lab=Do4}
N 3130 -740 3150 -740 {
lab=Do5}
N 3130 -720 3150 -720 {
lab=Do6}
N 3130 -700 3150 -700 {
lab=Do7}
N 3130 -680 3150 -680 {
lab=Do8}
N 3130 -660 3150 -660 {
lab=Do9}
N 3130 -640 3150 -640 {
lab=Do10}
N 3130 -620 3150 -620 {
lab=Do11}
N 3130 -600 3150 -600 {
lab=Do12}
N 3130 -580 3150 -580 {
lab=Do13}
N 3130 -560 3150 -560 {
lab=Do14}
N 3130 -540 3150 -540 {
lab=Do15}
N 3130 -520 3150 -520 {
lab=Do16}
N 3130 -500 3150 -500 {
lab=Do17}
N 3130 -480 3150 -480 {
lab=Do18}
N 3130 -460 3150 -460 {
lab=Do19}
N 3130 -440 3150 -440 {
lab=Do20}
N 3130 -420 3150 -420 {
lab=Do21}
N 3130 -400 3150 -400 {
lab=Do22}
N 3130 -380 3150 -380 {
lab=Do23}
N 3130 -360 3150 -360 {
lab=Do24}
N 3130 -340 3150 -340 {
lab=Do25}
N 3130 -320 3150 -320 {
lab=Do26}
N 3130 -300 3150 -300 {
lab=Do27}
N 3130 -280 3150 -280 {
lab=Do28}
N 3130 -260 3150 -260 {
lab=Do29}
N 3130 -240 3150 -240 {
lab=Do30}
N 3130 -220 3150 -220 {
lab=Do31}
N 3640 -2690 3660 -2690 {
lab=Do0}
N 3640 -2670 3660 -2670 {
lab=Do1}
N 3640 -2650 3660 -2650 {
lab=Do2}
N 3640 -2630 3660 -2630 {
lab=Do3}
N 3640 -2610 3660 -2610 {
lab=Do4}
N 3640 -2590 3660 -2590 {
lab=Do5}
N 3640 -2570 3660 -2570 {
lab=Do6}
N 3640 -2550 3660 -2550 {
lab=Do7}
N 3640 -2530 3660 -2530 {
lab=Do8}
N 3640 -2510 3660 -2510 {
lab=Do9}
N 3640 -2490 3660 -2490 {
lab=Do10}
N 3640 -2470 3660 -2470 {
lab=Do11}
N 3640 -2450 3660 -2450 {
lab=Do12}
N 3640 -2430 3660 -2430 {
lab=Do13}
N 3640 -2410 3660 -2410 {
lab=Do14}
N 3640 -2390 3660 -2390 {
lab=Do15}
N 3640 -2370 3660 -2370 {
lab=Do16}
N 3640 -2350 3660 -2350 {
lab=Do17}
N 3640 -2330 3660 -2330 {
lab=Do18}
N 3640 -2310 3660 -2310 {
lab=Do19}
N 3640 -2290 3660 -2290 {
lab=Do20}
N 3640 -2270 3660 -2270 {
lab=Do21}
N 3640 -2250 3660 -2250 {
lab=Do22}
N 3640 -2230 3660 -2230 {
lab=Do23}
N 3640 -2210 3660 -2210 {
lab=Do24}
N 3640 -2190 3660 -2190 {
lab=Do25}
N 3640 -2170 3660 -2170 {
lab=Do26}
N 3640 -2150 3660 -2150 {
lab=Do27}
N 3640 -2130 3660 -2130 {
lab=Do28}
N 3640 -2110 3660 -2110 {
lab=Do29}
N 3640 -2090 3660 -2090 {
lab=Do30}
N 3640 -2070 3660 -2070 {
lab=Do31}
N 3650 -1740 3670 -1740 {
lab=Do0}
N 3650 -1720 3670 -1720 {
lab=Do1}
N 3650 -1700 3670 -1700 {
lab=Do2}
N 3650 -1680 3670 -1680 {
lab=Do3}
N 3650 -1660 3670 -1660 {
lab=Do4}
N 3650 -1640 3670 -1640 {
lab=Do5}
N 3650 -1620 3670 -1620 {
lab=Do6}
N 3650 -1600 3670 -1600 {
lab=Do7}
N 3650 -1580 3670 -1580 {
lab=Do8}
N 3650 -1560 3670 -1560 {
lab=Do9}
N 3650 -1540 3670 -1540 {
lab=Do10}
N 3650 -1520 3670 -1520 {
lab=Do11}
N 3650 -1500 3670 -1500 {
lab=Do12}
N 3650 -1480 3670 -1480 {
lab=Do13}
N 3650 -1460 3670 -1460 {
lab=Do14}
N 3650 -1440 3670 -1440 {
lab=Do15}
N 3650 -1420 3670 -1420 {
lab=Do16}
N 3650 -1400 3670 -1400 {
lab=Do17}
N 3650 -1380 3670 -1380 {
lab=Do18}
N 3650 -1360 3670 -1360 {
lab=Do19}
N 3650 -1340 3670 -1340 {
lab=Do20}
N 3650 -1320 3670 -1320 {
lab=Do21}
N 3650 -1300 3670 -1300 {
lab=Do22}
N 3650 -1280 3670 -1280 {
lab=Do23}
N 3650 -1260 3670 -1260 {
lab=Do24}
N 3650 -1240 3670 -1240 {
lab=Do25}
N 3650 -1220 3670 -1220 {
lab=Do26}
N 3650 -1200 3670 -1200 {
lab=Do27}
N 3650 -1180 3670 -1180 {
lab=Do28}
N 3650 -1160 3670 -1160 {
lab=Do29}
N 3650 -1140 3670 -1140 {
lab=Do30}
N 3650 -1120 3670 -1120 {
lab=Do31}
N 3650 -840 3670 -840 {
lab=Do0}
N 3650 -820 3670 -820 {
lab=Do1}
N 3650 -800 3670 -800 {
lab=Do2}
N 3650 -780 3670 -780 {
lab=Do3}
N 3650 -760 3670 -760 {
lab=Do4}
N 3650 -740 3670 -740 {
lab=Do5}
N 3650 -720 3670 -720 {
lab=Do6}
N 3650 -700 3670 -700 {
lab=Do7}
N 3650 -680 3670 -680 {
lab=Do8}
N 3650 -660 3670 -660 {
lab=Do9}
N 3650 -640 3670 -640 {
lab=Do10}
N 3650 -620 3670 -620 {
lab=Do11}
N 3650 -600 3670 -600 {
lab=Do12}
N 3650 -580 3670 -580 {
lab=Do13}
N 3650 -560 3670 -560 {
lab=Do14}
N 3650 -540 3670 -540 {
lab=Do15}
N 3650 -520 3670 -520 {
lab=Do16}
N 3650 -500 3670 -500 {
lab=Do17}
N 3650 -480 3670 -480 {
lab=Do18}
N 3650 -460 3670 -460 {
lab=Do19}
N 3650 -440 3670 -440 {
lab=Do20}
N 3650 -420 3670 -420 {
lab=Do21}
N 3650 -400 3670 -400 {
lab=Do22}
N 3650 -380 3670 -380 {
lab=Do23}
N 3650 -360 3670 -360 {
lab=Do24}
N 3650 -340 3670 -340 {
lab=Do25}
N 3650 -320 3670 -320 {
lab=Do26}
N 3650 -300 3670 -300 {
lab=Do27}
N 3650 -280 3670 -280 {
lab=Do28}
N 3650 -260 3670 -260 {
lab=Do29}
N 3650 -240 3670 -240 {
lab=Do30}
N 3650 -220 3670 -220 {
lab=Do31}
N 4160 -2690 4180 -2690 {
lab=Do0}
N 4160 -2670 4180 -2670 {
lab=Do1}
N 4160 -2650 4180 -2650 {
lab=Do2}
N 4160 -2630 4180 -2630 {
lab=Do3}
N 4160 -2610 4180 -2610 {
lab=Do4}
N 4160 -2590 4180 -2590 {
lab=Do5}
N 4160 -2570 4180 -2570 {
lab=Do6}
N 4160 -2550 4180 -2550 {
lab=Do7}
N 4160 -2530 4180 -2530 {
lab=Do8}
N 4160 -2510 4180 -2510 {
lab=Do9}
N 4160 -2490 4180 -2490 {
lab=Do10}
N 4160 -2470 4180 -2470 {
lab=Do11}
N 4160 -2450 4180 -2450 {
lab=Do12}
N 4160 -2430 4180 -2430 {
lab=Do13}
N 4160 -2410 4180 -2410 {
lab=Do14}
N 4160 -2390 4180 -2390 {
lab=Do15}
N 4160 -2370 4180 -2370 {
lab=Do16}
N 4160 -2350 4180 -2350 {
lab=Do17}
N 4160 -2330 4180 -2330 {
lab=Do18}
N 4160 -2310 4180 -2310 {
lab=Do19}
N 4160 -2290 4180 -2290 {
lab=Do20}
N 4160 -2270 4180 -2270 {
lab=Do21}
N 4160 -2250 4180 -2250 {
lab=Do22}
N 4160 -2230 4180 -2230 {
lab=Do23}
N 4160 -2210 4180 -2210 {
lab=Do24}
N 4160 -2190 4180 -2190 {
lab=Do25}
N 4160 -2170 4180 -2170 {
lab=Do26}
N 4160 -2150 4180 -2150 {
lab=Do27}
N 4160 -2130 4180 -2130 {
lab=Do28}
N 4160 -2110 4180 -2110 {
lab=Do29}
N 4160 -2090 4180 -2090 {
lab=Do30}
N 4160 -2070 4180 -2070 {
lab=Do31}
N 4170 -1740 4190 -1740 {
lab=Do0}
N 4170 -1720 4190 -1720 {
lab=Do1}
N 4170 -1700 4190 -1700 {
lab=Do2}
N 4170 -1680 4190 -1680 {
lab=Do3}
N 4170 -1660 4190 -1660 {
lab=Do4}
N 4170 -1640 4190 -1640 {
lab=Do5}
N 4170 -1620 4190 -1620 {
lab=Do6}
N 4170 -1600 4190 -1600 {
lab=Do7}
N 4170 -1580 4190 -1580 {
lab=Do8}
N 4170 -1560 4190 -1560 {
lab=Do9}
N 4170 -1540 4190 -1540 {
lab=Do10}
N 4170 -1520 4190 -1520 {
lab=Do11}
N 4170 -1500 4190 -1500 {
lab=Do12}
N 4170 -1480 4190 -1480 {
lab=Do13}
N 4170 -1460 4190 -1460 {
lab=Do14}
N 4170 -1440 4190 -1440 {
lab=Do15}
N 4170 -1420 4190 -1420 {
lab=Do16}
N 4170 -1400 4190 -1400 {
lab=Do17}
N 4170 -1380 4190 -1380 {
lab=Do18}
N 4170 -1360 4190 -1360 {
lab=Do19}
N 4170 -1340 4190 -1340 {
lab=Do20}
N 4170 -1320 4190 -1320 {
lab=Do21}
N 4170 -1300 4190 -1300 {
lab=Do22}
N 4170 -1280 4190 -1280 {
lab=Do23}
N 4170 -1260 4190 -1260 {
lab=Do24}
N 4170 -1240 4190 -1240 {
lab=Do25}
N 4170 -1220 4190 -1220 {
lab=Do26}
N 4170 -1200 4190 -1200 {
lab=Do27}
N 4170 -1180 4190 -1180 {
lab=Do28}
N 4170 -1160 4190 -1160 {
lab=Do29}
N 4170 -1140 4190 -1140 {
lab=Do30}
N 4170 -1120 4190 -1120 {
lab=Do31}
N 4170 -840 4190 -840 {
lab=Do0}
N 4170 -820 4190 -820 {
lab=Do1}
N 4170 -800 4190 -800 {
lab=Do2}
N 4170 -780 4190 -780 {
lab=Do3}
N 4170 -760 4190 -760 {
lab=Do4}
N 4170 -740 4190 -740 {
lab=Do5}
N 4170 -720 4190 -720 {
lab=Do6}
N 4170 -700 4190 -700 {
lab=Do7}
N 4170 -680 4190 -680 {
lab=Do8}
N 4170 -660 4190 -660 {
lab=Do9}
N 4170 -640 4190 -640 {
lab=Do10}
N 4170 -620 4190 -620 {
lab=Do11}
N 4170 -600 4190 -600 {
lab=Do12}
N 4170 -580 4190 -580 {
lab=Do13}
N 4170 -560 4190 -560 {
lab=Do14}
N 4170 -540 4190 -540 {
lab=Do15}
N 4170 -520 4190 -520 {
lab=Do16}
N 4170 -500 4190 -500 {
lab=Do17}
N 4170 -480 4190 -480 {
lab=Do18}
N 4170 -460 4190 -460 {
lab=Do19}
N 4170 -440 4190 -440 {
lab=Do20}
N 4170 -420 4190 -420 {
lab=Do21}
N 4170 -400 4190 -400 {
lab=Do22}
N 4170 -380 4190 -380 {
lab=Do23}
N 4170 -360 4190 -360 {
lab=Do24}
N 4170 -340 4190 -340 {
lab=Do25}
N 4170 -320 4190 -320 {
lab=Do26}
N 4170 -300 4190 -300 {
lab=Do27}
N 4170 -280 4190 -280 {
lab=Do28}
N 4170 -260 4190 -260 {
lab=Do29}
N 4170 -240 4190 -240 {
lab=Do30}
N 4170 -220 4190 -220 {
lab=Do31}
N 4680 -2690 4700 -2690 {
lab=Do0}
N 4680 -2670 4700 -2670 {
lab=Do1}
N 4680 -2650 4700 -2650 {
lab=Do2}
N 4680 -2630 4700 -2630 {
lab=Do3}
N 4680 -2610 4700 -2610 {
lab=Do4}
N 4680 -2590 4700 -2590 {
lab=Do5}
N 4680 -2570 4700 -2570 {
lab=Do6}
N 4680 -2550 4700 -2550 {
lab=Do7}
N 4680 -2530 4700 -2530 {
lab=Do8}
N 4680 -2510 4700 -2510 {
lab=Do9}
N 4680 -2490 4700 -2490 {
lab=Do10}
N 4680 -2470 4700 -2470 {
lab=Do11}
N 4680 -2450 4700 -2450 {
lab=Do12}
N 4680 -2430 4700 -2430 {
lab=Do13}
N 4680 -2410 4700 -2410 {
lab=Do14}
N 4680 -2390 4700 -2390 {
lab=Do15}
N 4680 -2370 4700 -2370 {
lab=Do16}
N 4680 -2350 4700 -2350 {
lab=Do17}
N 4680 -2330 4700 -2330 {
lab=Do18}
N 4680 -2310 4700 -2310 {
lab=Do19}
N 4680 -2290 4700 -2290 {
lab=Do20}
N 4680 -2270 4700 -2270 {
lab=Do21}
N 4680 -2250 4700 -2250 {
lab=Do22}
N 4680 -2230 4700 -2230 {
lab=Do23}
N 4680 -2210 4700 -2210 {
lab=Do24}
N 4680 -2190 4700 -2190 {
lab=Do25}
N 4680 -2170 4700 -2170 {
lab=Do26}
N 4680 -2150 4700 -2150 {
lab=Do27}
N 4680 -2130 4700 -2130 {
lab=Do28}
N 4680 -2110 4700 -2110 {
lab=Do29}
N 4680 -2090 4700 -2090 {
lab=Do30}
N 4680 -2070 4700 -2070 {
lab=Do31}
N 4690 -1740 4710 -1740 {
lab=Do0}
N 4690 -1720 4710 -1720 {
lab=Do1}
N 4690 -1700 4710 -1700 {
lab=Do2}
N 4690 -1680 4710 -1680 {
lab=Do3}
N 4690 -1660 4710 -1660 {
lab=Do4}
N 4690 -1640 4710 -1640 {
lab=Do5}
N 4690 -1620 4710 -1620 {
lab=Do6}
N 4690 -1600 4710 -1600 {
lab=Do7}
N 4690 -1580 4710 -1580 {
lab=Do8}
N 4690 -1560 4710 -1560 {
lab=Do9}
N 4690 -1540 4710 -1540 {
lab=Do10}
N 4690 -1520 4710 -1520 {
lab=Do11}
N 4690 -1500 4710 -1500 {
lab=Do12}
N 4690 -1480 4710 -1480 {
lab=Do13}
N 4690 -1460 4710 -1460 {
lab=Do14}
N 4690 -1440 4710 -1440 {
lab=Do15}
N 4690 -1420 4710 -1420 {
lab=Do16}
N 4690 -1400 4710 -1400 {
lab=Do17}
N 4690 -1380 4710 -1380 {
lab=Do18}
N 4690 -1360 4710 -1360 {
lab=Do19}
N 4690 -1340 4710 -1340 {
lab=Do20}
N 4690 -1320 4710 -1320 {
lab=Do21}
N 4690 -1300 4710 -1300 {
lab=Do22}
N 4690 -1280 4710 -1280 {
lab=Do23}
N 4690 -1260 4710 -1260 {
lab=Do24}
N 4690 -1240 4710 -1240 {
lab=Do25}
N 4690 -1220 4710 -1220 {
lab=Do26}
N 4690 -1200 4710 -1200 {
lab=Do27}
N 4690 -1180 4710 -1180 {
lab=Do28}
N 4690 -1160 4710 -1160 {
lab=Do29}
N 4690 -1140 4710 -1140 {
lab=Do30}
N 4690 -1120 4710 -1120 {
lab=Do31}
N 4690 -840 4710 -840 {
lab=Do0}
N 4690 -820 4710 -820 {
lab=Do1}
N 4690 -800 4710 -800 {
lab=Do2}
N 4690 -780 4710 -780 {
lab=Do3}
N 4690 -760 4710 -760 {
lab=Do4}
N 4690 -740 4710 -740 {
lab=Do5}
N 4690 -720 4710 -720 {
lab=Do6}
N 4690 -700 4710 -700 {
lab=Do7}
N 4690 -680 4710 -680 {
lab=Do8}
N 4690 -660 4710 -660 {
lab=Do9}
N 4690 -640 4710 -640 {
lab=Do10}
N 4690 -620 4710 -620 {
lab=Do11}
N 4690 -600 4710 -600 {
lab=Do12}
N 4690 -580 4710 -580 {
lab=Do13}
N 4690 -560 4710 -560 {
lab=Do14}
N 4690 -540 4710 -540 {
lab=Do15}
N 4690 -520 4710 -520 {
lab=Do16}
N 4690 -500 4710 -500 {
lab=Do17}
N 4690 -480 4710 -480 {
lab=Do18}
N 4690 -460 4710 -460 {
lab=Do19}
N 4690 -440 4710 -440 {
lab=Do20}
N 4690 -420 4710 -420 {
lab=Do21}
N 4690 -400 4710 -400 {
lab=Do22}
N 4690 -380 4710 -380 {
lab=Do23}
N 4690 -360 4710 -360 {
lab=Do24}
N 4690 -340 4710 -340 {
lab=Do25}
N 4690 -320 4710 -320 {
lab=Do26}
N 4690 -300 4710 -300 {
lab=Do27}
N 4690 -280 4710 -280 {
lab=Do28}
N 4690 -260 4710 -260 {
lab=Do29}
N 4690 -240 4710 -240 {
lab=Do30}
N 4690 -220 4710 -220 {
lab=Do31}
N 5220 -2690 5240 -2690 {
lab=Do0}
N 5220 -2670 5240 -2670 {
lab=Do1}
N 5220 -2650 5240 -2650 {
lab=Do2}
N 5220 -2630 5240 -2630 {
lab=Do3}
N 5220 -2610 5240 -2610 {
lab=Do4}
N 5220 -2590 5240 -2590 {
lab=Do5}
N 5220 -2570 5240 -2570 {
lab=Do6}
N 5220 -2550 5240 -2550 {
lab=Do7}
N 5220 -2530 5240 -2530 {
lab=Do8}
N 5220 -2510 5240 -2510 {
lab=Do9}
N 5220 -2490 5240 -2490 {
lab=Do10}
N 5220 -2470 5240 -2470 {
lab=Do11}
N 5220 -2450 5240 -2450 {
lab=Do12}
N 5220 -2430 5240 -2430 {
lab=Do13}
N 5220 -2410 5240 -2410 {
lab=Do14}
N 5220 -2390 5240 -2390 {
lab=Do15}
N 5220 -2370 5240 -2370 {
lab=Do16}
N 5220 -2350 5240 -2350 {
lab=Do17}
N 5220 -2330 5240 -2330 {
lab=Do18}
N 5220 -2310 5240 -2310 {
lab=Do19}
N 5220 -2290 5240 -2290 {
lab=Do20}
N 5220 -2270 5240 -2270 {
lab=Do21}
N 5220 -2250 5240 -2250 {
lab=Do22}
N 5220 -2230 5240 -2230 {
lab=Do23}
N 5220 -2210 5240 -2210 {
lab=Do24}
N 5220 -2190 5240 -2190 {
lab=Do25}
N 5220 -2170 5240 -2170 {
lab=Do26}
N 5220 -2150 5240 -2150 {
lab=Do27}
N 5220 -2130 5240 -2130 {
lab=Do28}
N 5220 -2110 5240 -2110 {
lab=Do29}
N 5220 -2090 5240 -2090 {
lab=Do30}
N 5220 -2070 5240 -2070 {
lab=Do31}
N 5230 -1740 5250 -1740 {
lab=Do0}
N 5230 -1720 5250 -1720 {
lab=Do1}
N 5230 -1700 5250 -1700 {
lab=Do2}
N 5230 -1680 5250 -1680 {
lab=Do3}
N 5230 -1660 5250 -1660 {
lab=Do4}
N 5230 -1640 5250 -1640 {
lab=Do5}
N 5230 -1620 5250 -1620 {
lab=Do6}
N 5230 -1600 5250 -1600 {
lab=Do7}
N 5230 -1580 5250 -1580 {
lab=Do8}
N 5230 -1560 5250 -1560 {
lab=Do9}
N 5230 -1540 5250 -1540 {
lab=Do10}
N 5230 -1520 5250 -1520 {
lab=Do11}
N 5230 -1500 5250 -1500 {
lab=Do12}
N 5230 -1480 5250 -1480 {
lab=Do13}
N 5230 -1460 5250 -1460 {
lab=Do14}
N 5230 -1440 5250 -1440 {
lab=Do15}
N 5230 -1420 5250 -1420 {
lab=Do16}
N 5230 -1400 5250 -1400 {
lab=Do17}
N 5230 -1380 5250 -1380 {
lab=Do18}
N 5230 -1360 5250 -1360 {
lab=Do19}
N 5230 -1340 5250 -1340 {
lab=Do20}
N 5230 -1320 5250 -1320 {
lab=Do21}
N 5230 -1300 5250 -1300 {
lab=Do22}
N 5230 -1280 5250 -1280 {
lab=Do23}
N 5230 -1260 5250 -1260 {
lab=Do24}
N 5230 -1240 5250 -1240 {
lab=Do25}
N 5230 -1220 5250 -1220 {
lab=Do26}
N 5230 -1200 5250 -1200 {
lab=Do27}
N 5230 -1180 5250 -1180 {
lab=Do28}
N 5230 -1160 5250 -1160 {
lab=Do29}
N 5230 -1140 5250 -1140 {
lab=Do30}
N 5230 -1120 5250 -1120 {
lab=Do31}
N 5230 -840 5250 -840 {
lab=Do0}
N 5230 -820 5250 -820 {
lab=Do1}
N 5230 -800 5250 -800 {
lab=Do2}
N 5230 -780 5250 -780 {
lab=Do3}
N 5230 -760 5250 -760 {
lab=Do4}
N 5230 -740 5250 -740 {
lab=Do5}
N 5230 -720 5250 -720 {
lab=Do6}
N 5230 -700 5250 -700 {
lab=Do7}
N 5230 -680 5250 -680 {
lab=Do8}
N 5230 -660 5250 -660 {
lab=Do9}
N 5230 -640 5250 -640 {
lab=Do10}
N 5230 -620 5250 -620 {
lab=Do11}
N 5230 -600 5250 -600 {
lab=Do12}
N 5230 -580 5250 -580 {
lab=Do13}
N 5230 -560 5250 -560 {
lab=Do14}
N 5230 -540 5250 -540 {
lab=Do15}
N 5230 -520 5250 -520 {
lab=Do16}
N 5230 -500 5250 -500 {
lab=Do17}
N 5230 -480 5250 -480 {
lab=Do18}
N 5230 -460 5250 -460 {
lab=Do19}
N 5230 -440 5250 -440 {
lab=Do20}
N 5230 -420 5250 -420 {
lab=Do21}
N 5230 -400 5250 -400 {
lab=Do22}
N 5230 -380 5250 -380 {
lab=Do23}
N 5230 -360 5250 -360 {
lab=Do24}
N 5230 -340 5250 -340 {
lab=Do25}
N 5230 -320 5250 -320 {
lab=Do26}
N 5230 -300 5250 -300 {
lab=Do27}
N 5230 -280 5250 -280 {
lab=Do28}
N 5230 -260 5250 -260 {
lab=Do29}
N 5230 -240 5250 -240 {
lab=Do30}
N 5230 -220 5250 -220 {
lab=Do31}
N 5740 -2690 5760 -2690 {
lab=Do0}
N 5740 -2670 5760 -2670 {
lab=Do1}
N 5740 -2650 5760 -2650 {
lab=Do2}
N 5740 -2630 5760 -2630 {
lab=Do3}
N 5740 -2610 5760 -2610 {
lab=Do4}
N 5740 -2590 5760 -2590 {
lab=Do5}
N 5740 -2570 5760 -2570 {
lab=Do6}
N 5740 -2550 5760 -2550 {
lab=Do7}
N 5740 -2530 5760 -2530 {
lab=Do8}
N 5740 -2510 5760 -2510 {
lab=Do9}
N 5740 -2490 5760 -2490 {
lab=Do10}
N 5740 -2470 5760 -2470 {
lab=Do11}
N 5740 -2450 5760 -2450 {
lab=Do12}
N 5740 -2430 5760 -2430 {
lab=Do13}
N 5740 -2410 5760 -2410 {
lab=Do14}
N 5740 -2390 5760 -2390 {
lab=Do15}
N 5740 -2370 5760 -2370 {
lab=Do16}
N 5740 -2350 5760 -2350 {
lab=Do17}
N 5740 -2330 5760 -2330 {
lab=Do18}
N 5740 -2310 5760 -2310 {
lab=Do19}
N 5740 -2290 5760 -2290 {
lab=Do20}
N 5740 -2270 5760 -2270 {
lab=Do21}
N 5740 -2250 5760 -2250 {
lab=Do22}
N 5740 -2230 5760 -2230 {
lab=Do23}
N 5740 -2210 5760 -2210 {
lab=Do24}
N 5740 -2190 5760 -2190 {
lab=Do25}
N 5740 -2170 5760 -2170 {
lab=Do26}
N 5740 -2150 5760 -2150 {
lab=Do27}
N 5740 -2130 5760 -2130 {
lab=Do28}
N 5740 -2110 5760 -2110 {
lab=Do29}
N 5740 -2090 5760 -2090 {
lab=Do30}
N 5740 -2070 5760 -2070 {
lab=Do31}
N 5750 -1740 5770 -1740 {
lab=Do0}
N 5750 -1720 5770 -1720 {
lab=Do1}
N 5750 -1700 5770 -1700 {
lab=Do2}
N 5750 -1680 5770 -1680 {
lab=Do3}
N 5750 -1660 5770 -1660 {
lab=Do4}
N 5750 -1640 5770 -1640 {
lab=Do5}
N 5750 -1620 5770 -1620 {
lab=Do6}
N 5750 -1600 5770 -1600 {
lab=Do7}
N 5750 -1580 5770 -1580 {
lab=Do8}
N 5750 -1560 5770 -1560 {
lab=Do9}
N 5750 -1540 5770 -1540 {
lab=Do10}
N 5750 -1520 5770 -1520 {
lab=Do11}
N 5750 -1500 5770 -1500 {
lab=Do12}
N 5750 -1480 5770 -1480 {
lab=Do13}
N 5750 -1460 5770 -1460 {
lab=Do14}
N 5750 -1440 5770 -1440 {
lab=Do15}
N 5750 -1420 5770 -1420 {
lab=Do16}
N 5750 -1400 5770 -1400 {
lab=Do17}
N 5750 -1380 5770 -1380 {
lab=Do18}
N 5750 -1360 5770 -1360 {
lab=Do19}
N 5750 -1340 5770 -1340 {
lab=Do20}
N 5750 -1320 5770 -1320 {
lab=Do21}
N 5750 -1300 5770 -1300 {
lab=Do22}
N 5750 -1280 5770 -1280 {
lab=Do23}
N 5750 -1260 5770 -1260 {
lab=Do24}
N 5750 -1240 5770 -1240 {
lab=Do25}
N 5750 -1220 5770 -1220 {
lab=Do26}
N 5750 -1200 5770 -1200 {
lab=Do27}
N 5750 -1180 5770 -1180 {
lab=Do28}
N 5750 -1160 5770 -1160 {
lab=Do29}
N 5750 -1140 5770 -1140 {
lab=Do30}
N 5750 -1120 5770 -1120 {
lab=Do31}
N 5750 -840 5770 -840 {
lab=Do0}
N 5750 -820 5770 -820 {
lab=Do1}
N 5750 -800 5770 -800 {
lab=Do2}
N 5750 -780 5770 -780 {
lab=Do3}
N 5750 -760 5770 -760 {
lab=Do4}
N 5750 -740 5770 -740 {
lab=Do5}
N 5750 -720 5770 -720 {
lab=Do6}
N 5750 -700 5770 -700 {
lab=Do7}
N 5750 -680 5770 -680 {
lab=Do8}
N 5750 -660 5770 -660 {
lab=Do9}
N 5750 -640 5770 -640 {
lab=Do10}
N 5750 -620 5770 -620 {
lab=Do11}
N 5750 -600 5770 -600 {
lab=Do12}
N 5750 -580 5770 -580 {
lab=Do13}
N 5750 -560 5770 -560 {
lab=Do14}
N 5750 -540 5770 -540 {
lab=Do15}
N 5750 -520 5770 -520 {
lab=Do16}
N 5750 -500 5770 -500 {
lab=Do17}
N 5750 -480 5770 -480 {
lab=Do18}
N 5750 -460 5770 -460 {
lab=Do19}
N 5750 -440 5770 -440 {
lab=Do20}
N 5750 -420 5770 -420 {
lab=Do21}
N 5750 -400 5770 -400 {
lab=Do22}
N 5750 -380 5770 -380 {
lab=Do23}
N 5750 -360 5770 -360 {
lab=Do24}
N 5750 -340 5770 -340 {
lab=Do25}
N 5750 -320 5770 -320 {
lab=Do26}
N 5750 -300 5770 -300 {
lab=Do27}
N 5750 -280 5770 -280 {
lab=Do28}
N 5750 -260 5770 -260 {
lab=Do29}
N 5750 -240 5770 -240 {
lab=Do30}
N 5750 -220 5770 -220 {
lab=Do31}
C {xschem_lib/DFFRAM_full_custom/word.sym} 1910 -3340 0 0 {name=xbyte1 NF=2}
C {lab_wire.sym} 1740 -3590 0 0 {name=l1 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 1740 -3570 0 0 {name=l2 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 1740 -3550 0 0 {name=l3 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 1740 -3530 0 0 {name=l4 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 1740 -3510 0 0 {name=l5 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 1740 -3490 0 0 {name=l6 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 1740 -3470 0 0 {name=l7 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 1740 -3450 0 0 {name=l8 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 1740 -3430 0 0 {name=l9 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 1740 -3410 0 0 {name=l10 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 1740 -3390 0 0 {name=l11 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 1740 -3370 0 0 {name=l12 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 1740 -3350 0 0 {name=l13 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 1740 -3330 0 0 {name=l14 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 1740 -3310 0 0 {name=l15 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 1740 -3290 0 0 {name=l16 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 1740 -3270 0 0 {name=l17 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 1740 -3250 0 0 {name=l18 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 1740 -3230 0 0 {name=l19 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 1740 -3210 0 0 {name=l20 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 1740 -3190 0 0 {name=l21 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 1740 -3170 0 0 {name=l22 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 1740 -3150 0 0 {name=l23 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 1740 -3130 0 0 {name=l24 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 1740 -3110 0 0 {name=l25 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 1740 -3090 0 0 {name=l26 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 1740 -3070 0 0 {name=l27 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 1740 -3050 0 0 {name=l28 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 1740 -3030 0 0 {name=l29 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 1740 -3010 0 0 {name=l30 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 1740 -2970 0 0 {name=l31 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 1740 -2990 0 0 {name=l32 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2080 -3590 2 0 {name=l33 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 2080 -3570 2 0 {name=l34 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 2080 -3550 2 0 {name=l35 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 2080 -3530 2 0 {name=l36 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 2080 -3510 2 0 {name=l37 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 2080 -3490 2 0 {name=l38 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 2080 -3470 2 0 {name=l39 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 2080 -3450 2 0 {name=l40 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 2080 -3430 2 0 {name=l41 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 2080 -3410 2 0 {name=l42 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 2080 -3390 2 0 {name=l43 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 2080 -3370 2 0 {name=l44 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 2080 -3350 2 0 {name=l45 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 2080 -3330 2 0 {name=l46 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 2080 -3310 2 0 {name=l47 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 2080 -3290 2 0 {name=l48 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 2080 -3270 2 0 {name=l49 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 2080 -3250 2 0 {name=l50 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 2080 -3230 2 0 {name=l51 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 2080 -3210 2 0 {name=l52 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 2080 -3190 2 0 {name=l53 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 2080 -3170 2 0 {name=l54 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 2080 -3150 2 0 {name=l55 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 2080 -3130 2 0 {name=l56 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 2080 -3110 2 0 {name=l57 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 2080 -3090 2 0 {name=l58 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 2080 -3070 2 0 {name=l59 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 2080 -3050 2 0 {name=l60 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 2080 -3030 2 0 {name=l61 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 2080 -3010 2 0 {name=l62 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 2080 -2990 2 0 {name=l63 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 2080 -2970 2 0 {name=l64 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 1830 -3650 0 0 {name=l65 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 1870 -3650 1 0 {name=l66 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 1890 -3650 1 0 {name=l67 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 1910 -3650 1 0 {name=l68 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 1930 -3650 1 0 {name=l69 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 1960 -3650 1 0 {name=l70 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1980 -3650 1 0 {name=l71 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 2430 -3340 0 0 {name=xbyte2 NF=2}
C {lab_wire.sym} 2260 -3590 0 0 {name=l72 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 2260 -3570 0 0 {name=l73 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 2260 -3550 0 0 {name=l74 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 2260 -3530 0 0 {name=l75 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 2260 -3510 0 0 {name=l76 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 2260 -3490 0 0 {name=l77 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 2260 -3470 0 0 {name=l78 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 2260 -3450 0 0 {name=l79 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 2260 -3430 0 0 {name=l80 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 2260 -3410 0 0 {name=l81 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 2260 -3390 0 0 {name=l82 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 2260 -3370 0 0 {name=l83 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 2260 -3350 0 0 {name=l84 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 2260 -3330 0 0 {name=l85 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 2260 -3310 0 0 {name=l86 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 2260 -3290 0 0 {name=l87 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 2260 -3270 0 0 {name=l88 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 2260 -3250 0 0 {name=l89 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2260 -3230 0 0 {name=l90 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2260 -3210 0 0 {name=l91 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2260 -3190 0 0 {name=l92 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2260 -3170 0 0 {name=l93 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2260 -3150 0 0 {name=l94 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2260 -3130 0 0 {name=l95 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2260 -3110 0 0 {name=l96 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2260 -3090 0 0 {name=l97 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2260 -3070 0 0 {name=l98 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2260 -3050 0 0 {name=l99 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2260 -3030 0 0 {name=l100 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2260 -3010 0 0 {name=l101 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2260 -2970 0 0 {name=l102 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2260 -2990 0 0 {name=l103 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2350 -3650 0 0 {name=l136 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2390 -3650 1 0 {name=l137 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 2410 -3650 1 0 {name=l138 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 2430 -3650 1 0 {name=l139 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 2450 -3650 1 0 {name=l140 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 2480 -3650 1 0 {name=l141 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2500 -3650 1 0 {name=l142 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 2970 -3340 0 0 {name=xbyte3 NF=2}
C {lab_wire.sym} 2800 -3590 0 0 {name=l143 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 2800 -3570 0 0 {name=l144 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 2800 -3550 0 0 {name=l145 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 2800 -3530 0 0 {name=l146 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 2800 -3510 0 0 {name=l147 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 2800 -3490 0 0 {name=l148 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 2800 -3470 0 0 {name=l149 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 2800 -3450 0 0 {name=l150 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 2800 -3430 0 0 {name=l151 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 2800 -3410 0 0 {name=l152 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 2800 -3390 0 0 {name=l153 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 2800 -3370 0 0 {name=l154 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 2800 -3350 0 0 {name=l155 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 2800 -3330 0 0 {name=l156 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 2800 -3310 0 0 {name=l157 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 2800 -3290 0 0 {name=l158 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 2800 -3270 0 0 {name=l159 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 2800 -3250 0 0 {name=l160 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2800 -3230 0 0 {name=l161 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2800 -3210 0 0 {name=l162 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2800 -3190 0 0 {name=l163 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2800 -3170 0 0 {name=l164 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2800 -3150 0 0 {name=l165 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2800 -3130 0 0 {name=l166 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2800 -3110 0 0 {name=l167 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2800 -3090 0 0 {name=l168 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2800 -3070 0 0 {name=l169 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2800 -3050 0 0 {name=l170 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2800 -3030 0 0 {name=l171 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2800 -3010 0 0 {name=l172 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2800 -2970 0 0 {name=l173 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2800 -2990 0 0 {name=l174 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2890 -3650 0 0 {name=l207 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2930 -3650 1 0 {name=l208 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 2950 -3650 1 0 {name=l209 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 2970 -3650 1 0 {name=l210 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 2990 -3650 1 0 {name=l211 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 3020 -3650 1 0 {name=l212 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3040 -3650 1 0 {name=l213 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 3490 -3340 0 0 {name=xbyte4 NF=2}
C {lab_wire.sym} 3320 -3590 0 0 {name=l214 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 3320 -3570 0 0 {name=l215 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 3320 -3550 0 0 {name=l216 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 3320 -3530 0 0 {name=l217 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 3320 -3510 0 0 {name=l218 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 3320 -3490 0 0 {name=l219 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 3320 -3470 0 0 {name=l220 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 3320 -3450 0 0 {name=l221 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 3320 -3430 0 0 {name=l222 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 3320 -3410 0 0 {name=l223 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 3320 -3390 0 0 {name=l224 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 3320 -3370 0 0 {name=l225 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 3320 -3350 0 0 {name=l226 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 3320 -3330 0 0 {name=l227 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 3320 -3310 0 0 {name=l228 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 3320 -3290 0 0 {name=l229 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 3320 -3270 0 0 {name=l230 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 3320 -3250 0 0 {name=l231 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3320 -3230 0 0 {name=l232 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3320 -3210 0 0 {name=l233 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3320 -3190 0 0 {name=l234 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3320 -3170 0 0 {name=l235 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3320 -3150 0 0 {name=l236 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3320 -3130 0 0 {name=l237 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3320 -3110 0 0 {name=l238 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3320 -3090 0 0 {name=l239 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3320 -3070 0 0 {name=l240 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3320 -3050 0 0 {name=l241 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3320 -3030 0 0 {name=l242 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3320 -3010 0 0 {name=l243 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3320 -2970 0 0 {name=l244 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3320 -2990 0 0 {name=l245 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3410 -3650 0 0 {name=l278 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3450 -3650 1 0 {name=l279 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 3470 -3650 1 0 {name=l280 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 3490 -3650 1 0 {name=l281 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 3510 -3650 1 0 {name=l282 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 3540 -3650 1 0 {name=l283 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3560 -3650 1 0 {name=l284 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 4010 -3340 0 0 {name=xbyte5 NF=2}
C {lab_wire.sym} 3840 -3590 0 0 {name=l285 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 3840 -3570 0 0 {name=l286 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 3840 -3550 0 0 {name=l287 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 3840 -3530 0 0 {name=l288 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 3840 -3510 0 0 {name=l289 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 3840 -3490 0 0 {name=l290 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 3840 -3470 0 0 {name=l291 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 3840 -3450 0 0 {name=l292 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 3840 -3430 0 0 {name=l293 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 3840 -3410 0 0 {name=l294 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 3840 -3390 0 0 {name=l295 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 3840 -3370 0 0 {name=l296 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 3840 -3350 0 0 {name=l297 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 3840 -3330 0 0 {name=l298 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 3840 -3310 0 0 {name=l299 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 3840 -3290 0 0 {name=l300 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 3840 -3270 0 0 {name=l301 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 3840 -3250 0 0 {name=l302 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3840 -3230 0 0 {name=l303 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3840 -3210 0 0 {name=l304 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3840 -3190 0 0 {name=l305 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3840 -3170 0 0 {name=l306 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3840 -3150 0 0 {name=l307 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3840 -3130 0 0 {name=l308 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3840 -3110 0 0 {name=l309 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3840 -3090 0 0 {name=l310 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3840 -3070 0 0 {name=l311 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3840 -3050 0 0 {name=l312 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3840 -3030 0 0 {name=l313 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3840 -3010 0 0 {name=l314 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3840 -2970 0 0 {name=l315 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3840 -2990 0 0 {name=l316 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3930 -3650 0 0 {name=l349 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3970 -3650 1 0 {name=l350 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 3990 -3650 1 0 {name=l351 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 4010 -3650 1 0 {name=l352 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 4030 -3650 1 0 {name=l353 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 4060 -3650 1 0 {name=l354 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4080 -3650 1 0 {name=l355 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 4530 -3340 0 0 {name=xbyte6 NF=2}
C {lab_wire.sym} 4360 -3590 0 0 {name=l356 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 4360 -3570 0 0 {name=l357 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 4360 -3550 0 0 {name=l358 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 4360 -3530 0 0 {name=l359 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 4360 -3510 0 0 {name=l360 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 4360 -3490 0 0 {name=l361 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 4360 -3470 0 0 {name=l362 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 4360 -3450 0 0 {name=l363 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 4360 -3430 0 0 {name=l364 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 4360 -3410 0 0 {name=l365 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 4360 -3390 0 0 {name=l366 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 4360 -3370 0 0 {name=l367 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 4360 -3350 0 0 {name=l368 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 4360 -3330 0 0 {name=l369 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 4360 -3310 0 0 {name=l370 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 4360 -3290 0 0 {name=l371 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 4360 -3270 0 0 {name=l372 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 4360 -3250 0 0 {name=l373 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 4360 -3230 0 0 {name=l374 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 4360 -3210 0 0 {name=l375 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 4360 -3190 0 0 {name=l376 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 4360 -3170 0 0 {name=l377 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 4360 -3150 0 0 {name=l378 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 4360 -3130 0 0 {name=l379 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 4360 -3110 0 0 {name=l380 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 4360 -3090 0 0 {name=l381 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 4360 -3070 0 0 {name=l382 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 4360 -3050 0 0 {name=l383 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 4360 -3030 0 0 {name=l384 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 4360 -3010 0 0 {name=l385 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 4360 -2970 0 0 {name=l386 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 4360 -2990 0 0 {name=l387 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 4450 -3650 0 0 {name=l420 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 4490 -3650 1 0 {name=l421 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 4510 -3650 1 0 {name=l422 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 4530 -3650 1 0 {name=l423 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 4550 -3650 1 0 {name=l424 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 4580 -3650 1 0 {name=l425 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4600 -3650 1 0 {name=l426 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 5070 -3340 0 0 {name=xbyte7 NF=2}
C {lab_wire.sym} 4900 -3590 0 0 {name=l427 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 4900 -3570 0 0 {name=l428 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 4900 -3550 0 0 {name=l429 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 4900 -3530 0 0 {name=l430 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 4900 -3510 0 0 {name=l431 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 4900 -3490 0 0 {name=l432 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 4900 -3470 0 0 {name=l433 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 4900 -3450 0 0 {name=l434 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 4900 -3430 0 0 {name=l435 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 4900 -3410 0 0 {name=l436 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 4900 -3390 0 0 {name=l437 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 4900 -3370 0 0 {name=l438 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 4900 -3350 0 0 {name=l439 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 4900 -3330 0 0 {name=l440 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 4900 -3310 0 0 {name=l441 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 4900 -3290 0 0 {name=l442 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 4900 -3270 0 0 {name=l443 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 4900 -3250 0 0 {name=l444 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 4900 -3230 0 0 {name=l445 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 4900 -3210 0 0 {name=l446 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 4900 -3190 0 0 {name=l447 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 4900 -3170 0 0 {name=l448 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 4900 -3150 0 0 {name=l449 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 4900 -3130 0 0 {name=l450 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 4900 -3110 0 0 {name=l451 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 4900 -3090 0 0 {name=l452 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 4900 -3070 0 0 {name=l453 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 4900 -3050 0 0 {name=l454 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 4900 -3030 0 0 {name=l455 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 4900 -3010 0 0 {name=l456 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 4900 -2970 0 0 {name=l457 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 4900 -2990 0 0 {name=l458 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 5030 -3650 1 0 {name=l492 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5050 -3650 1 0 {name=l493 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 5070 -3650 1 0 {name=l494 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 5090 -3650 1 0 {name=l495 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 5120 -3650 1 0 {name=l496 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5140 -3650 1 0 {name=l497 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 5590 -3340 0 0 {name=xbyte8 NF=2}
C {lab_wire.sym} 5420 -3590 0 0 {name=l498 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 5420 -3570 0 0 {name=l499 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 5420 -3550 0 0 {name=l500 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 5420 -3530 0 0 {name=l501 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 5420 -3510 0 0 {name=l502 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 5420 -3490 0 0 {name=l503 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 5420 -3470 0 0 {name=l504 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 5420 -3450 0 0 {name=l505 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 5420 -3430 0 0 {name=l506 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 5420 -3410 0 0 {name=l507 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 5420 -3390 0 0 {name=l508 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 5420 -3370 0 0 {name=l509 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 5420 -3350 0 0 {name=l510 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 5420 -3330 0 0 {name=l511 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 5420 -3310 0 0 {name=l512 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 5420 -3290 0 0 {name=l513 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 5420 -3270 0 0 {name=l514 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 5420 -3250 0 0 {name=l515 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 5420 -3230 0 0 {name=l516 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 5420 -3210 0 0 {name=l517 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 5420 -3190 0 0 {name=l518 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 5420 -3170 0 0 {name=l519 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 5420 -3150 0 0 {name=l520 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 5420 -3130 0 0 {name=l521 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 5420 -3110 0 0 {name=l522 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 5420 -3090 0 0 {name=l523 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 5420 -3070 0 0 {name=l524 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 5420 -3050 0 0 {name=l525 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 5420 -3030 0 0 {name=l526 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 5420 -3010 0 0 {name=l527 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 5420 -2970 0 0 {name=l528 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 5420 -2990 0 0 {name=l529 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 5550 -3650 1 0 {name=l563 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5570 -3650 1 0 {name=l564 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 5590 -3650 1 0 {name=l565 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 5610 -3650 1 0 {name=l566 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 5640 -3650 1 0 {name=l567 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5660 -3650 1 0 {name=l568 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 1910 -2440 0 0 {name=xbyte9 NF=2}
C {lab_wire.sym} 1740 -2690 0 0 {name=l569 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 1740 -2670 0 0 {name=l570 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 1740 -2650 0 0 {name=l571 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 1740 -2630 0 0 {name=l572 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 1740 -2610 0 0 {name=l573 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 1740 -2590 0 0 {name=l574 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 1740 -2570 0 0 {name=l575 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 1740 -2550 0 0 {name=l576 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 1740 -2530 0 0 {name=l577 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 1740 -2510 0 0 {name=l578 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 1740 -2490 0 0 {name=l579 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 1740 -2470 0 0 {name=l580 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 1740 -2450 0 0 {name=l581 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 1740 -2430 0 0 {name=l582 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 1740 -2410 0 0 {name=l583 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 1740 -2390 0 0 {name=l584 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 1740 -2370 0 0 {name=l585 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 1740 -2350 0 0 {name=l586 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 1740 -2330 0 0 {name=l587 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 1740 -2310 0 0 {name=l588 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 1740 -2290 0 0 {name=l589 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 1740 -2270 0 0 {name=l590 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 1740 -2250 0 0 {name=l591 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 1740 -2230 0 0 {name=l592 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 1740 -2210 0 0 {name=l593 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 1740 -2190 0 0 {name=l594 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 1740 -2170 0 0 {name=l595 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 1740 -2150 0 0 {name=l596 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 1740 -2130 0 0 {name=l597 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 1740 -2110 0 0 {name=l598 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 1740 -2070 0 0 {name=l599 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 1740 -2090 0 0 {name=l600 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 1870 -2750 1 0 {name=l634 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 1890 -2750 1 0 {name=l635 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 1910 -2750 1 0 {name=l636 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 1930 -2750 1 0 {name=l637 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 1960 -2750 1 0 {name=l638 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1980 -2750 1 0 {name=l639 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 2430 -2440 0 0 {name=xbyte10 NF=2}
C {lab_wire.sym} 2260 -2690 0 0 {name=l640 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 2260 -2670 0 0 {name=l641 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 2260 -2650 0 0 {name=l642 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 2260 -2630 0 0 {name=l643 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 2260 -2610 0 0 {name=l644 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 2260 -2590 0 0 {name=l645 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 2260 -2570 0 0 {name=l646 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 2260 -2550 0 0 {name=l647 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 2260 -2530 0 0 {name=l648 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 2260 -2510 0 0 {name=l649 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 2260 -2490 0 0 {name=l650 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 2260 -2470 0 0 {name=l651 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 2260 -2450 0 0 {name=l652 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 2260 -2430 0 0 {name=l653 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 2260 -2410 0 0 {name=l654 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 2260 -2390 0 0 {name=l655 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 2260 -2370 0 0 {name=l656 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 2260 -2350 0 0 {name=l657 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2260 -2330 0 0 {name=l658 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2260 -2310 0 0 {name=l659 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2260 -2290 0 0 {name=l660 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2260 -2270 0 0 {name=l661 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2260 -2250 0 0 {name=l662 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2260 -2230 0 0 {name=l663 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2260 -2210 0 0 {name=l664 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2260 -2190 0 0 {name=l665 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2260 -2170 0 0 {name=l666 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2260 -2150 0 0 {name=l667 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2260 -2130 0 0 {name=l668 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2260 -2110 0 0 {name=l669 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2260 -2070 0 0 {name=l670 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2260 -2090 0 0 {name=l671 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2390 -2750 1 0 {name=l705 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 2410 -2750 1 0 {name=l706 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 2430 -2750 1 0 {name=l707 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 2450 -2750 1 0 {name=l708 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 2480 -2750 1 0 {name=l709 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2500 -2750 1 0 {name=l710 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 2970 -2440 0 0 {name=xbyte11 NF=2}
C {lab_wire.sym} 2800 -2690 0 0 {name=l711 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 2800 -2670 0 0 {name=l712 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 2800 -2650 0 0 {name=l713 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 2800 -2630 0 0 {name=l714 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 2800 -2610 0 0 {name=l715 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 2800 -2590 0 0 {name=l716 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 2800 -2570 0 0 {name=l717 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 2800 -2550 0 0 {name=l718 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 2800 -2530 0 0 {name=l719 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 2800 -2510 0 0 {name=l720 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 2800 -2490 0 0 {name=l721 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 2800 -2470 0 0 {name=l722 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 2800 -2450 0 0 {name=l723 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 2800 -2430 0 0 {name=l724 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 2800 -2410 0 0 {name=l725 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 2800 -2390 0 0 {name=l726 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 2800 -2370 0 0 {name=l727 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 2800 -2350 0 0 {name=l728 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2800 -2330 0 0 {name=l729 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2800 -2310 0 0 {name=l730 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2800 -2290 0 0 {name=l731 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2800 -2270 0 0 {name=l732 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2800 -2250 0 0 {name=l733 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2800 -2230 0 0 {name=l734 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2800 -2210 0 0 {name=l735 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2800 -2190 0 0 {name=l736 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2800 -2170 0 0 {name=l737 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2800 -2150 0 0 {name=l738 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2800 -2130 0 0 {name=l739 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2800 -2110 0 0 {name=l740 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2800 -2070 0 0 {name=l741 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2800 -2090 0 0 {name=l742 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2930 -2750 1 0 {name=l776 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 2950 -2750 1 0 {name=l777 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 2970 -2750 1 0 {name=l778 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 2990 -2750 1 0 {name=l779 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 3020 -2750 1 0 {name=l780 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3040 -2750 1 0 {name=l781 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 3490 -2440 0 0 {name=xbyte12 NF=2}
C {lab_wire.sym} 3320 -2690 0 0 {name=l782 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 3320 -2670 0 0 {name=l783 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 3320 -2650 0 0 {name=l784 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 3320 -2630 0 0 {name=l785 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 3320 -2610 0 0 {name=l786 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 3320 -2590 0 0 {name=l787 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 3320 -2570 0 0 {name=l788 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 3320 -2550 0 0 {name=l789 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 3320 -2530 0 0 {name=l790 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 3320 -2510 0 0 {name=l791 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 3320 -2490 0 0 {name=l792 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 3320 -2470 0 0 {name=l793 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 3320 -2450 0 0 {name=l794 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 3320 -2430 0 0 {name=l795 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 3320 -2410 0 0 {name=l796 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 3320 -2390 0 0 {name=l797 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 3320 -2370 0 0 {name=l798 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 3320 -2350 0 0 {name=l799 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3320 -2330 0 0 {name=l800 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3320 -2310 0 0 {name=l801 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3320 -2290 0 0 {name=l802 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3320 -2270 0 0 {name=l803 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3320 -2250 0 0 {name=l804 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3320 -2230 0 0 {name=l805 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3320 -2210 0 0 {name=l806 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3320 -2190 0 0 {name=l807 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3320 -2170 0 0 {name=l808 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3320 -2150 0 0 {name=l809 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3320 -2130 0 0 {name=l810 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3320 -2110 0 0 {name=l811 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3320 -2070 0 0 {name=l812 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3320 -2090 0 0 {name=l813 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3450 -2750 1 0 {name=l847 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 3470 -2750 1 0 {name=l848 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 3490 -2750 1 0 {name=l849 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 3510 -2750 1 0 {name=l850 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 3540 -2750 1 0 {name=l851 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3560 -2750 1 0 {name=l852 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 4010 -2440 0 0 {name=xbyte13 NF=2}
C {lab_wire.sym} 3840 -2690 0 0 {name=l853 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 3840 -2670 0 0 {name=l854 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 3840 -2650 0 0 {name=l855 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 3840 -2630 0 0 {name=l856 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 3840 -2610 0 0 {name=l857 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 3840 -2590 0 0 {name=l858 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 3840 -2570 0 0 {name=l859 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 3840 -2550 0 0 {name=l860 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 3840 -2530 0 0 {name=l861 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 3840 -2510 0 0 {name=l862 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 3840 -2490 0 0 {name=l863 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 3840 -2470 0 0 {name=l864 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 3840 -2450 0 0 {name=l865 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 3840 -2430 0 0 {name=l866 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 3840 -2410 0 0 {name=l867 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 3840 -2390 0 0 {name=l868 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 3840 -2370 0 0 {name=l869 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 3840 -2350 0 0 {name=l870 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3840 -2330 0 0 {name=l871 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3840 -2310 0 0 {name=l872 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3840 -2290 0 0 {name=l873 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3840 -2270 0 0 {name=l874 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3840 -2250 0 0 {name=l875 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3840 -2230 0 0 {name=l876 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3840 -2210 0 0 {name=l877 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3840 -2190 0 0 {name=l878 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3840 -2170 0 0 {name=l879 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3840 -2150 0 0 {name=l880 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3840 -2130 0 0 {name=l881 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3840 -2110 0 0 {name=l882 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3840 -2070 0 0 {name=l883 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3840 -2090 0 0 {name=l884 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3970 -2750 1 0 {name=l918 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 3990 -2750 1 0 {name=l919 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 4010 -2750 1 0 {name=l920 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 4030 -2750 1 0 {name=l921 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 4060 -2750 1 0 {name=l922 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4080 -2750 1 0 {name=l923 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 4530 -2440 0 0 {name=xbyte14 NF=2}
C {lab_wire.sym} 4360 -2690 0 0 {name=l924 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 4360 -2670 0 0 {name=l925 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 4360 -2650 0 0 {name=l926 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 4360 -2630 0 0 {name=l927 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 4360 -2610 0 0 {name=l928 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 4360 -2590 0 0 {name=l929 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 4360 -2570 0 0 {name=l930 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 4360 -2550 0 0 {name=l931 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 4360 -2530 0 0 {name=l932 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 4360 -2510 0 0 {name=l933 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 4360 -2490 0 0 {name=l934 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 4360 -2470 0 0 {name=l935 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 4360 -2450 0 0 {name=l936 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 4360 -2430 0 0 {name=l937 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 4360 -2410 0 0 {name=l938 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 4360 -2390 0 0 {name=l939 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 4360 -2370 0 0 {name=l940 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 4360 -2350 0 0 {name=l941 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 4360 -2330 0 0 {name=l942 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 4360 -2310 0 0 {name=l943 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 4360 -2290 0 0 {name=l944 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 4360 -2270 0 0 {name=l945 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 4360 -2250 0 0 {name=l946 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 4360 -2230 0 0 {name=l947 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 4360 -2210 0 0 {name=l948 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 4360 -2190 0 0 {name=l949 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 4360 -2170 0 0 {name=l950 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 4360 -2150 0 0 {name=l951 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 4360 -2130 0 0 {name=l952 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 4360 -2110 0 0 {name=l953 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 4360 -2070 0 0 {name=l954 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 4360 -2090 0 0 {name=l955 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 4490 -2750 1 0 {name=l989 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 4510 -2750 1 0 {name=l990 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 4530 -2750 1 0 {name=l991 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 4550 -2750 1 0 {name=l992 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 4580 -2750 1 0 {name=l993 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4600 -2750 1 0 {name=l994 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 5070 -2440 0 0 {name=xbyte15 NF=2}
C {lab_wire.sym} 4900 -2690 0 0 {name=l995 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 4900 -2670 0 0 {name=l996 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 4900 -2650 0 0 {name=l997 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 4900 -2630 0 0 {name=l998 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 4900 -2610 0 0 {name=l999 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 4900 -2590 0 0 {name=l1000 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 4900 -2570 0 0 {name=l1001 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 4900 -2550 0 0 {name=l1002 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 4900 -2530 0 0 {name=l1003 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 4900 -2510 0 0 {name=l1004 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 4900 -2490 0 0 {name=l1005 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 4900 -2470 0 0 {name=l1006 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 4900 -2450 0 0 {name=l1007 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 4900 -2430 0 0 {name=l1008 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 4900 -2410 0 0 {name=l1009 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 4900 -2390 0 0 {name=l1010 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 4900 -2370 0 0 {name=l1011 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 4900 -2350 0 0 {name=l1012 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 4900 -2330 0 0 {name=l1013 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 4900 -2310 0 0 {name=l1014 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 4900 -2290 0 0 {name=l1015 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 4900 -2270 0 0 {name=l1016 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 4900 -2250 0 0 {name=l1017 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 4900 -2230 0 0 {name=l1018 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 4900 -2210 0 0 {name=l1019 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 4900 -2190 0 0 {name=l1020 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 4900 -2170 0 0 {name=l1021 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 4900 -2150 0 0 {name=l1022 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 4900 -2130 0 0 {name=l1023 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 4900 -2110 0 0 {name=l1024 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 4900 -2070 0 0 {name=l1025 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 4900 -2090 0 0 {name=l1026 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 5030 -2750 1 0 {name=l1060 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5050 -2750 1 0 {name=l1061 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 5070 -2750 1 0 {name=l1062 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 5090 -2750 1 0 {name=l1063 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 5120 -2750 1 0 {name=l1064 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5140 -2750 1 0 {name=l1065 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 5590 -2440 0 0 {name=xbyte16 NF=2}
C {lab_wire.sym} 5420 -2690 0 0 {name=l1066 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 5420 -2670 0 0 {name=l1067 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 5420 -2650 0 0 {name=l1068 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 5420 -2630 0 0 {name=l1069 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 5420 -2610 0 0 {name=l1070 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 5420 -2590 0 0 {name=l1071 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 5420 -2570 0 0 {name=l1072 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 5420 -2550 0 0 {name=l1073 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 5420 -2530 0 0 {name=l1074 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 5420 -2510 0 0 {name=l1075 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 5420 -2490 0 0 {name=l1076 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 5420 -2470 0 0 {name=l1077 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 5420 -2450 0 0 {name=l1078 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 5420 -2430 0 0 {name=l1079 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 5420 -2410 0 0 {name=l1080 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 5420 -2390 0 0 {name=l1081 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 5420 -2370 0 0 {name=l1082 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 5420 -2350 0 0 {name=l1083 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 5420 -2330 0 0 {name=l1084 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 5420 -2310 0 0 {name=l1085 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 5420 -2290 0 0 {name=l1086 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 5420 -2270 0 0 {name=l1087 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 5420 -2250 0 0 {name=l1088 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 5420 -2230 0 0 {name=l1089 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 5420 -2210 0 0 {name=l1090 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 5420 -2190 0 0 {name=l1091 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 5420 -2170 0 0 {name=l1092 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 5420 -2150 0 0 {name=l1093 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 5420 -2130 0 0 {name=l1094 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 5420 -2110 0 0 {name=l1095 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 5420 -2070 0 0 {name=l1096 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 5420 -2090 0 0 {name=l1097 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 5550 -2750 1 0 {name=l1131 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5570 -2750 1 0 {name=l1132 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 5590 -2750 1 0 {name=l1133 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 5610 -2750 1 0 {name=l1134 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 5640 -2750 1 0 {name=l1135 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5660 -2750 1 0 {name=l1136 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 1920 -1490 0 0 {name=xbyte17 NF=2}
C {lab_wire.sym} 1750 -1740 0 0 {name=l1137 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 1750 -1720 0 0 {name=l1138 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 1750 -1700 0 0 {name=l1139 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 1750 -1680 0 0 {name=l1140 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 1750 -1660 0 0 {name=l1141 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 1750 -1640 0 0 {name=l1142 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 1750 -1620 0 0 {name=l1143 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 1750 -1600 0 0 {name=l1144 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 1750 -1580 0 0 {name=l1145 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 1750 -1560 0 0 {name=l1146 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 1750 -1540 0 0 {name=l1147 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 1750 -1520 0 0 {name=l1148 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 1750 -1500 0 0 {name=l1149 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 1750 -1480 0 0 {name=l1150 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 1750 -1460 0 0 {name=l1151 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 1750 -1440 0 0 {name=l1152 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 1750 -1420 0 0 {name=l1153 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 1750 -1400 0 0 {name=l1154 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 1750 -1380 0 0 {name=l1155 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 1750 -1360 0 0 {name=l1156 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 1750 -1340 0 0 {name=l1157 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 1750 -1320 0 0 {name=l1158 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 1750 -1300 0 0 {name=l1159 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 1750 -1280 0 0 {name=l1160 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 1750 -1260 0 0 {name=l1161 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 1750 -1240 0 0 {name=l1162 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 1750 -1220 0 0 {name=l1163 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 1750 -1200 0 0 {name=l1164 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 1750 -1180 0 0 {name=l1165 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 1750 -1160 0 0 {name=l1166 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 1750 -1120 0 0 {name=l1167 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 1750 -1140 0 0 {name=l1168 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 1880 -1800 1 0 {name=l1202 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 1900 -1800 1 0 {name=l1203 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 1920 -1800 1 0 {name=l1204 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 1940 -1800 1 0 {name=l1205 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 1970 -1800 1 0 {name=l1206 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1990 -1800 1 0 {name=l1207 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 2440 -1490 0 0 {name=xbyte18 NF=2}
C {lab_wire.sym} 2270 -1740 0 0 {name=l1208 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 2270 -1720 0 0 {name=l1209 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 2270 -1700 0 0 {name=l1210 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 2270 -1680 0 0 {name=l1211 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 2270 -1660 0 0 {name=l1212 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 2270 -1640 0 0 {name=l1213 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 2270 -1620 0 0 {name=l1214 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 2270 -1600 0 0 {name=l1215 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 2270 -1580 0 0 {name=l1216 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 2270 -1560 0 0 {name=l1217 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 2270 -1540 0 0 {name=l1218 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 2270 -1520 0 0 {name=l1219 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 2270 -1500 0 0 {name=l1220 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 2270 -1480 0 0 {name=l1221 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 2270 -1460 0 0 {name=l1222 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 2270 -1440 0 0 {name=l1223 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 2270 -1420 0 0 {name=l1224 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 2270 -1400 0 0 {name=l1225 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2270 -1380 0 0 {name=l1226 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2270 -1360 0 0 {name=l1227 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2270 -1340 0 0 {name=l1228 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2270 -1320 0 0 {name=l1229 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2270 -1300 0 0 {name=l1230 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2270 -1280 0 0 {name=l1231 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2270 -1260 0 0 {name=l1232 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2270 -1240 0 0 {name=l1233 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2270 -1220 0 0 {name=l1234 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2270 -1200 0 0 {name=l1235 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2270 -1180 0 0 {name=l1236 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2270 -1160 0 0 {name=l1237 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2270 -1120 0 0 {name=l1238 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2270 -1140 0 0 {name=l1239 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2400 -1800 1 0 {name=l1273 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 2420 -1800 1 0 {name=l1274 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 2440 -1800 1 0 {name=l1275 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 2460 -1800 1 0 {name=l1276 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 2490 -1800 1 0 {name=l1277 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2510 -1800 1 0 {name=l1278 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 2980 -1490 0 0 {name=xbyte19 NF=2}
C {lab_wire.sym} 2810 -1740 0 0 {name=l1279 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 2810 -1720 0 0 {name=l1280 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 2810 -1700 0 0 {name=l1281 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 2810 -1680 0 0 {name=l1282 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 2810 -1660 0 0 {name=l1283 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 2810 -1640 0 0 {name=l1284 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 2810 -1620 0 0 {name=l1285 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 2810 -1600 0 0 {name=l1286 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 2810 -1580 0 0 {name=l1287 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 2810 -1560 0 0 {name=l1288 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 2810 -1540 0 0 {name=l1289 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 2810 -1520 0 0 {name=l1290 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 2810 -1500 0 0 {name=l1291 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 2810 -1480 0 0 {name=l1292 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 2810 -1460 0 0 {name=l1293 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 2810 -1440 0 0 {name=l1294 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 2810 -1420 0 0 {name=l1295 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 2810 -1400 0 0 {name=l1296 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2810 -1380 0 0 {name=l1297 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2810 -1360 0 0 {name=l1298 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2810 -1340 0 0 {name=l1299 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2810 -1320 0 0 {name=l1300 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2810 -1300 0 0 {name=l1301 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2810 -1280 0 0 {name=l1302 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2810 -1260 0 0 {name=l1303 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2810 -1240 0 0 {name=l1304 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2810 -1220 0 0 {name=l1305 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2810 -1200 0 0 {name=l1306 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2810 -1180 0 0 {name=l1307 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2810 -1160 0 0 {name=l1308 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2810 -1120 0 0 {name=l1309 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2810 -1140 0 0 {name=l1310 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2940 -1800 1 0 {name=l1344 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 2960 -1800 1 0 {name=l1345 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 2980 -1800 1 0 {name=l1346 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 3000 -1800 1 0 {name=l1347 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 3030 -1800 1 0 {name=l1348 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3050 -1800 1 0 {name=l1349 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 3500 -1490 0 0 {name=xbyte20 NF=2}
C {lab_wire.sym} 3330 -1740 0 0 {name=l1350 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 3330 -1720 0 0 {name=l1351 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 3330 -1700 0 0 {name=l1352 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 3330 -1680 0 0 {name=l1353 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 3330 -1660 0 0 {name=l1354 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 3330 -1640 0 0 {name=l1355 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 3330 -1620 0 0 {name=l1356 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 3330 -1600 0 0 {name=l1357 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 3330 -1580 0 0 {name=l1358 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 3330 -1560 0 0 {name=l1359 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 3330 -1540 0 0 {name=l1360 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 3330 -1520 0 0 {name=l1361 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 3330 -1500 0 0 {name=l1362 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 3330 -1480 0 0 {name=l1363 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 3330 -1460 0 0 {name=l1364 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 3330 -1440 0 0 {name=l1365 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 3330 -1420 0 0 {name=l1366 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 3330 -1400 0 0 {name=l1367 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3330 -1380 0 0 {name=l1368 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3330 -1360 0 0 {name=l1369 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3330 -1340 0 0 {name=l1370 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3330 -1320 0 0 {name=l1371 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3330 -1300 0 0 {name=l1372 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3330 -1280 0 0 {name=l1373 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3330 -1260 0 0 {name=l1374 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3330 -1240 0 0 {name=l1375 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3330 -1220 0 0 {name=l1376 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3330 -1200 0 0 {name=l1377 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3330 -1180 0 0 {name=l1378 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3330 -1160 0 0 {name=l1379 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3330 -1120 0 0 {name=l1380 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3330 -1140 0 0 {name=l1381 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3460 -1800 1 0 {name=l1415 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 3480 -1800 1 0 {name=l1416 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 3500 -1800 1 0 {name=l1417 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 3520 -1800 1 0 {name=l1418 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 3550 -1800 1 0 {name=l1419 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3570 -1800 1 0 {name=l1420 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 4020 -1490 0 0 {name=xbyte21 NF=2}
C {lab_wire.sym} 3850 -1740 0 0 {name=l1421 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 3850 -1720 0 0 {name=l1422 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 3850 -1700 0 0 {name=l1423 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 3850 -1680 0 0 {name=l1424 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 3850 -1660 0 0 {name=l1425 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 3850 -1640 0 0 {name=l1426 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 3850 -1620 0 0 {name=l1427 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 3850 -1600 0 0 {name=l1428 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 3850 -1580 0 0 {name=l1429 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 3850 -1560 0 0 {name=l1430 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 3850 -1540 0 0 {name=l1431 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 3850 -1520 0 0 {name=l1432 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 3850 -1500 0 0 {name=l1433 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 3850 -1480 0 0 {name=l1434 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 3850 -1460 0 0 {name=l1435 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 3850 -1440 0 0 {name=l1436 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 3850 -1420 0 0 {name=l1437 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 3850 -1400 0 0 {name=l1438 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3850 -1380 0 0 {name=l1439 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3850 -1360 0 0 {name=l1440 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3850 -1340 0 0 {name=l1441 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3850 -1320 0 0 {name=l1442 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3850 -1300 0 0 {name=l1443 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3850 -1280 0 0 {name=l1444 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3850 -1260 0 0 {name=l1445 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3850 -1240 0 0 {name=l1446 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3850 -1220 0 0 {name=l1447 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3850 -1200 0 0 {name=l1448 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3850 -1180 0 0 {name=l1449 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3850 -1160 0 0 {name=l1450 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3850 -1120 0 0 {name=l1451 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3850 -1140 0 0 {name=l1452 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3980 -1800 1 0 {name=l1486 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 4000 -1800 1 0 {name=l1487 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 4020 -1800 1 0 {name=l1488 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 4040 -1800 1 0 {name=l1489 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 4070 -1800 1 0 {name=l1490 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4090 -1800 1 0 {name=l1491 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 4540 -1490 0 0 {name=xbyte22 NF=2}
C {lab_wire.sym} 4370 -1740 0 0 {name=l1492 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 4370 -1720 0 0 {name=l1493 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 4370 -1700 0 0 {name=l1494 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 4370 -1680 0 0 {name=l1495 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 4370 -1660 0 0 {name=l1496 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 4370 -1640 0 0 {name=l1497 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 4370 -1620 0 0 {name=l1498 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 4370 -1600 0 0 {name=l1499 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 4370 -1580 0 0 {name=l1500 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 4370 -1560 0 0 {name=l1501 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 4370 -1540 0 0 {name=l1502 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 4370 -1520 0 0 {name=l1503 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 4370 -1500 0 0 {name=l1504 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 4370 -1480 0 0 {name=l1505 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 4370 -1460 0 0 {name=l1506 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 4370 -1440 0 0 {name=l1507 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 4370 -1420 0 0 {name=l1508 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 4370 -1400 0 0 {name=l1509 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 4370 -1380 0 0 {name=l1510 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 4370 -1360 0 0 {name=l1511 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 4370 -1340 0 0 {name=l1512 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 4370 -1320 0 0 {name=l1513 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 4370 -1300 0 0 {name=l1514 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 4370 -1280 0 0 {name=l1515 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 4370 -1260 0 0 {name=l1516 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 4370 -1240 0 0 {name=l1517 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 4370 -1220 0 0 {name=l1518 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 4370 -1200 0 0 {name=l1519 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 4370 -1180 0 0 {name=l1520 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 4370 -1160 0 0 {name=l1521 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 4370 -1120 0 0 {name=l1522 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 4370 -1140 0 0 {name=l1523 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 4500 -1800 1 0 {name=l1557 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 4520 -1800 1 0 {name=l1558 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 4540 -1800 1 0 {name=l1559 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 4560 -1800 1 0 {name=l1560 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 4590 -1800 1 0 {name=l1561 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4610 -1800 1 0 {name=l1562 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 5080 -1490 0 0 {name=xbyte23 NF=2}
C {lab_wire.sym} 4910 -1740 0 0 {name=l1563 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 4910 -1720 0 0 {name=l1564 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 4910 -1700 0 0 {name=l1565 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 4910 -1680 0 0 {name=l1566 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 4910 -1660 0 0 {name=l1567 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 4910 -1640 0 0 {name=l1568 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 4910 -1620 0 0 {name=l1569 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 4910 -1600 0 0 {name=l1570 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 4910 -1580 0 0 {name=l1571 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 4910 -1560 0 0 {name=l1572 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 4910 -1540 0 0 {name=l1573 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 4910 -1520 0 0 {name=l1574 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 4910 -1500 0 0 {name=l1575 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 4910 -1480 0 0 {name=l1576 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 4910 -1460 0 0 {name=l1577 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 4910 -1440 0 0 {name=l1578 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 4910 -1420 0 0 {name=l1579 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 4910 -1400 0 0 {name=l1580 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 4910 -1380 0 0 {name=l1581 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 4910 -1360 0 0 {name=l1582 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 4910 -1340 0 0 {name=l1583 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 4910 -1320 0 0 {name=l1584 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 4910 -1300 0 0 {name=l1585 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 4910 -1280 0 0 {name=l1586 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 4910 -1260 0 0 {name=l1587 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 4910 -1240 0 0 {name=l1588 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 4910 -1220 0 0 {name=l1589 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 4910 -1200 0 0 {name=l1590 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 4910 -1180 0 0 {name=l1591 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 4910 -1160 0 0 {name=l1592 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 4910 -1120 0 0 {name=l1593 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 4910 -1140 0 0 {name=l1594 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 5040 -1800 1 0 {name=l1628 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5060 -1800 1 0 {name=l1629 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 5080 -1800 1 0 {name=l1630 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 5100 -1800 1 0 {name=l1631 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 5130 -1800 1 0 {name=l1632 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5150 -1800 1 0 {name=l1633 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 5600 -1490 0 0 {name=xbyte24 NF=2}
C {lab_wire.sym} 5430 -1740 0 0 {name=l1634 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 5430 -1720 0 0 {name=l1635 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 5430 -1700 0 0 {name=l1636 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 5430 -1680 0 0 {name=l1637 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 5430 -1660 0 0 {name=l1638 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 5430 -1640 0 0 {name=l1639 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 5430 -1620 0 0 {name=l1640 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 5430 -1600 0 0 {name=l1641 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 5430 -1580 0 0 {name=l1642 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 5430 -1560 0 0 {name=l1643 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 5430 -1540 0 0 {name=l1644 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 5430 -1520 0 0 {name=l1645 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 5430 -1500 0 0 {name=l1646 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 5430 -1480 0 0 {name=l1647 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 5430 -1460 0 0 {name=l1648 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 5430 -1440 0 0 {name=l1649 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 5430 -1420 0 0 {name=l1650 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 5430 -1400 0 0 {name=l1651 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 5430 -1380 0 0 {name=l1652 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 5430 -1360 0 0 {name=l1653 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 5430 -1340 0 0 {name=l1654 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 5430 -1320 0 0 {name=l1655 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 5430 -1300 0 0 {name=l1656 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 5430 -1280 0 0 {name=l1657 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 5430 -1260 0 0 {name=l1658 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 5430 -1240 0 0 {name=l1659 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 5430 -1220 0 0 {name=l1660 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 5430 -1200 0 0 {name=l1661 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 5430 -1180 0 0 {name=l1662 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 5430 -1160 0 0 {name=l1663 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 5430 -1120 0 0 {name=l1664 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 5430 -1140 0 0 {name=l1665 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 5560 -1800 1 0 {name=l1699 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5580 -1800 1 0 {name=l1700 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 5600 -1800 1 0 {name=l1701 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 5620 -1800 1 0 {name=l1702 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 5650 -1800 1 0 {name=l1703 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5670 -1800 1 0 {name=l1704 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 1920 -590 0 0 {name=xbyte25 NF=2}
C {lab_wire.sym} 1750 -840 0 0 {name=l1705 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 1750 -820 0 0 {name=l1706 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 1750 -800 0 0 {name=l1707 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 1750 -780 0 0 {name=l1708 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 1750 -760 0 0 {name=l1709 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 1750 -740 0 0 {name=l1710 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 1750 -720 0 0 {name=l1711 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 1750 -700 0 0 {name=l1712 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 1750 -680 0 0 {name=l1713 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 1750 -660 0 0 {name=l1714 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 1750 -640 0 0 {name=l1715 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 1750 -620 0 0 {name=l1716 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 1750 -600 0 0 {name=l1717 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 1750 -580 0 0 {name=l1718 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 1750 -560 0 0 {name=l1719 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 1750 -540 0 0 {name=l1720 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 1750 -520 0 0 {name=l1721 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 1750 -500 0 0 {name=l1722 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 1750 -480 0 0 {name=l1723 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 1750 -460 0 0 {name=l1724 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 1750 -440 0 0 {name=l1725 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 1750 -420 0 0 {name=l1726 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 1750 -400 0 0 {name=l1727 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 1750 -380 0 0 {name=l1728 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 1750 -360 0 0 {name=l1729 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 1750 -340 0 0 {name=l1730 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 1750 -320 0 0 {name=l1731 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 1750 -300 0 0 {name=l1732 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 1750 -280 0 0 {name=l1733 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 1750 -260 0 0 {name=l1734 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 1750 -220 0 0 {name=l1735 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 1750 -240 0 0 {name=l1736 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 1880 -900 1 0 {name=l1770 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 1900 -900 1 0 {name=l1771 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 1920 -900 1 0 {name=l1772 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 1940 -900 1 0 {name=l1773 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 1970 -900 1 0 {name=l1774 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1990 -900 1 0 {name=l1775 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 2440 -590 0 0 {name=xbyte26 NF=2}
C {lab_wire.sym} 2270 -840 0 0 {name=l1776 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 2270 -820 0 0 {name=l1777 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 2270 -800 0 0 {name=l1778 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 2270 -780 0 0 {name=l1779 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 2270 -760 0 0 {name=l1780 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 2270 -740 0 0 {name=l1781 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 2270 -720 0 0 {name=l1782 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 2270 -700 0 0 {name=l1783 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 2270 -680 0 0 {name=l1784 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 2270 -660 0 0 {name=l1785 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 2270 -640 0 0 {name=l1786 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 2270 -620 0 0 {name=l1787 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 2270 -600 0 0 {name=l1788 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 2270 -580 0 0 {name=l1789 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 2270 -560 0 0 {name=l1790 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 2270 -540 0 0 {name=l1791 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 2270 -520 0 0 {name=l1792 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 2270 -500 0 0 {name=l1793 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2270 -480 0 0 {name=l1794 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2270 -460 0 0 {name=l1795 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2270 -440 0 0 {name=l1796 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2270 -420 0 0 {name=l1797 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2270 -400 0 0 {name=l1798 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2270 -380 0 0 {name=l1799 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2270 -360 0 0 {name=l1800 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2270 -340 0 0 {name=l1801 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2270 -320 0 0 {name=l1802 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2270 -300 0 0 {name=l1803 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2270 -280 0 0 {name=l1804 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2270 -260 0 0 {name=l1805 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2270 -220 0 0 {name=l1806 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2270 -240 0 0 {name=l1807 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2400 -900 1 0 {name=l1841 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 2420 -900 1 0 {name=l1842 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 2440 -900 1 0 {name=l1843 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 2460 -900 1 0 {name=l1844 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 2490 -900 1 0 {name=l1845 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2510 -900 1 0 {name=l1846 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 2980 -590 0 0 {name=xbyte27 NF=2}
C {lab_wire.sym} 2810 -840 0 0 {name=l1847 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 2810 -820 0 0 {name=l1848 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 2810 -800 0 0 {name=l1849 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 2810 -780 0 0 {name=l1850 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 2810 -760 0 0 {name=l1851 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 2810 -740 0 0 {name=l1852 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 2810 -720 0 0 {name=l1853 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 2810 -700 0 0 {name=l1854 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 2810 -680 0 0 {name=l1855 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 2810 -660 0 0 {name=l1856 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 2810 -640 0 0 {name=l1857 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 2810 -620 0 0 {name=l1858 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 2810 -600 0 0 {name=l1859 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 2810 -580 0 0 {name=l1860 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 2810 -560 0 0 {name=l1861 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 2810 -540 0 0 {name=l1862 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 2810 -520 0 0 {name=l1863 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 2810 -500 0 0 {name=l1864 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2810 -480 0 0 {name=l1865 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2810 -460 0 0 {name=l1866 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2810 -440 0 0 {name=l1867 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2810 -420 0 0 {name=l1868 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2810 -400 0 0 {name=l1869 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2810 -380 0 0 {name=l1870 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2810 -360 0 0 {name=l1871 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2810 -340 0 0 {name=l1872 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2810 -320 0 0 {name=l1873 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2810 -300 0 0 {name=l1874 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2810 -280 0 0 {name=l1875 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2810 -260 0 0 {name=l1876 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2810 -220 0 0 {name=l1877 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2810 -240 0 0 {name=l1878 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2940 -900 1 0 {name=l1912 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 2960 -900 1 0 {name=l1913 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 2980 -900 1 0 {name=l1914 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 3000 -900 1 0 {name=l1915 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 3030 -900 1 0 {name=l1916 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3050 -900 1 0 {name=l1917 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 3500 -590 0 0 {name=xbyte28 NF=2}
C {lab_wire.sym} 3330 -840 0 0 {name=l1918 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 3330 -820 0 0 {name=l1919 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 3330 -800 0 0 {name=l1920 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 3330 -780 0 0 {name=l1921 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 3330 -760 0 0 {name=l1922 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 3330 -740 0 0 {name=l1923 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 3330 -720 0 0 {name=l1924 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 3330 -700 0 0 {name=l1925 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 3330 -680 0 0 {name=l1926 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 3330 -660 0 0 {name=l1927 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 3330 -640 0 0 {name=l1928 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 3330 -620 0 0 {name=l1929 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 3330 -600 0 0 {name=l1930 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 3330 -580 0 0 {name=l1931 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 3330 -560 0 0 {name=l1932 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 3330 -540 0 0 {name=l1933 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 3330 -520 0 0 {name=l1934 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 3330 -500 0 0 {name=l1935 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3330 -480 0 0 {name=l1936 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3330 -460 0 0 {name=l1937 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3330 -440 0 0 {name=l1938 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3330 -420 0 0 {name=l1939 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3330 -400 0 0 {name=l1940 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3330 -380 0 0 {name=l1941 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3330 -360 0 0 {name=l1942 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3330 -340 0 0 {name=l1943 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3330 -320 0 0 {name=l1944 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3330 -300 0 0 {name=l1945 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3330 -280 0 0 {name=l1946 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3330 -260 0 0 {name=l1947 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3330 -220 0 0 {name=l1948 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3330 -240 0 0 {name=l1949 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3460 -900 1 0 {name=l1983 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 3480 -900 1 0 {name=l1984 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 3500 -900 1 0 {name=l1985 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 3520 -900 1 0 {name=l1986 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 3550 -900 1 0 {name=l1987 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3570 -900 1 0 {name=l1988 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 4020 -590 0 0 {name=xbyte29 NF=2}
C {lab_wire.sym} 3850 -840 0 0 {name=l1989 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 3850 -820 0 0 {name=l1990 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 3850 -800 0 0 {name=l1991 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 3850 -780 0 0 {name=l1992 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 3850 -760 0 0 {name=l1993 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 3850 -740 0 0 {name=l1994 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 3850 -720 0 0 {name=l1995 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 3850 -700 0 0 {name=l1996 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 3850 -680 0 0 {name=l1997 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 3850 -660 0 0 {name=l1998 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 3850 -640 0 0 {name=l1999 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 3850 -620 0 0 {name=l2000 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 3850 -600 0 0 {name=l2001 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 3850 -580 0 0 {name=l2002 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 3850 -560 0 0 {name=l2003 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 3850 -540 0 0 {name=l2004 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 3850 -520 0 0 {name=l2005 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 3850 -500 0 0 {name=l2006 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3850 -480 0 0 {name=l2007 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3850 -460 0 0 {name=l2008 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3850 -440 0 0 {name=l2009 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3850 -420 0 0 {name=l2010 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3850 -400 0 0 {name=l2011 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3850 -380 0 0 {name=l2012 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3850 -360 0 0 {name=l2013 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3850 -340 0 0 {name=l2014 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3850 -320 0 0 {name=l2015 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3850 -300 0 0 {name=l2016 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3850 -280 0 0 {name=l2017 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3850 -260 0 0 {name=l2018 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3850 -220 0 0 {name=l2019 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3850 -240 0 0 {name=l2020 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3980 -900 1 0 {name=l2054 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 4000 -900 1 0 {name=l2055 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 4020 -900 1 0 {name=l2056 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 4040 -900 1 0 {name=l2057 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 4070 -900 1 0 {name=l2058 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4090 -900 1 0 {name=l2059 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 4540 -590 0 0 {name=xbyte30 NF=2}
C {lab_wire.sym} 4370 -840 0 0 {name=l2060 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 4370 -820 0 0 {name=l2061 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 4370 -800 0 0 {name=l2062 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 4370 -780 0 0 {name=l2063 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 4370 -760 0 0 {name=l2064 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 4370 -740 0 0 {name=l2065 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 4370 -720 0 0 {name=l2066 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 4370 -700 0 0 {name=l2067 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 4370 -680 0 0 {name=l2068 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 4370 -660 0 0 {name=l2069 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 4370 -640 0 0 {name=l2070 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 4370 -620 0 0 {name=l2071 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 4370 -600 0 0 {name=l2072 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 4370 -580 0 0 {name=l2073 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 4370 -560 0 0 {name=l2074 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 4370 -540 0 0 {name=l2075 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 4370 -520 0 0 {name=l2076 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 4370 -500 0 0 {name=l2077 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 4370 -480 0 0 {name=l2078 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 4370 -460 0 0 {name=l2079 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 4370 -440 0 0 {name=l2080 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 4370 -420 0 0 {name=l2081 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 4370 -400 0 0 {name=l2082 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 4370 -380 0 0 {name=l2083 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 4370 -360 0 0 {name=l2084 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 4370 -340 0 0 {name=l2085 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 4370 -320 0 0 {name=l2086 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 4370 -300 0 0 {name=l2087 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 4370 -280 0 0 {name=l2088 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 4370 -260 0 0 {name=l2089 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 4370 -220 0 0 {name=l2090 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 4370 -240 0 0 {name=l2091 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 4500 -900 1 0 {name=l2125 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 4520 -900 1 0 {name=l2126 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 4540 -900 1 0 {name=l2127 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 4560 -900 1 0 {name=l2128 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 4590 -900 1 0 {name=l2129 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4610 -900 1 0 {name=l2130 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 5080 -590 0 0 {name=xbyte31 NF=2}
C {lab_wire.sym} 4910 -840 0 0 {name=l2131 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 4910 -820 0 0 {name=l2132 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 4910 -800 0 0 {name=l2133 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 4910 -780 0 0 {name=l2134 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 4910 -760 0 0 {name=l2135 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 4910 -740 0 0 {name=l2136 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 4910 -720 0 0 {name=l2137 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 4910 -700 0 0 {name=l2138 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 4910 -680 0 0 {name=l2139 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 4910 -660 0 0 {name=l2140 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 4910 -640 0 0 {name=l2141 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 4910 -620 0 0 {name=l2142 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 4910 -600 0 0 {name=l2143 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 4910 -580 0 0 {name=l2144 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 4910 -560 0 0 {name=l2145 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 4910 -540 0 0 {name=l2146 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 4910 -520 0 0 {name=l2147 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 4910 -500 0 0 {name=l2148 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 4910 -480 0 0 {name=l2149 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 4910 -460 0 0 {name=l2150 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 4910 -440 0 0 {name=l2151 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 4910 -420 0 0 {name=l2152 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 4910 -400 0 0 {name=l2153 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 4910 -380 0 0 {name=l2154 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 4910 -360 0 0 {name=l2155 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 4910 -340 0 0 {name=l2156 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 4910 -320 0 0 {name=l2157 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 4910 -300 0 0 {name=l2158 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 4910 -280 0 0 {name=l2159 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 4910 -260 0 0 {name=l2160 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 4910 -220 0 0 {name=l2161 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 4910 -240 0 0 {name=l2162 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 5040 -900 1 0 {name=l2196 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5060 -900 1 0 {name=l2197 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 5080 -900 1 0 {name=l2198 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 5100 -900 1 0 {name=l2199 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 5130 -900 1 0 {name=l2200 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5150 -900 1 0 {name=l2201 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 5600 -590 0 0 {name=xbyte32 NF=2}
C {lab_wire.sym} 5430 -840 0 0 {name=l2202 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 5430 -820 0 0 {name=l2203 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 5430 -800 0 0 {name=l2204 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 5430 -780 0 0 {name=l2205 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 5430 -760 0 0 {name=l2206 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 5430 -740 0 0 {name=l2207 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 5430 -720 0 0 {name=l2208 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 5430 -700 0 0 {name=l2209 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 5430 -680 0 0 {name=l2210 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 5430 -660 0 0 {name=l2211 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 5430 -640 0 0 {name=l2212 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 5430 -620 0 0 {name=l2213 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 5430 -600 0 0 {name=l2214 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 5430 -580 0 0 {name=l2215 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 5430 -560 0 0 {name=l2216 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 5430 -540 0 0 {name=l2217 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 5430 -520 0 0 {name=l2218 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 5430 -500 0 0 {name=l2219 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 5430 -480 0 0 {name=l2220 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 5430 -460 0 0 {name=l2221 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 5430 -440 0 0 {name=l2222 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 5430 -420 0 0 {name=l2223 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 5430 -400 0 0 {name=l2224 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 5430 -380 0 0 {name=l2225 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 5430 -360 0 0 {name=l2226 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 5430 -340 0 0 {name=l2227 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 5430 -320 0 0 {name=l2228 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 5430 -300 0 0 {name=l2229 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 5430 -280 0 0 {name=l2230 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 5430 -260 0 0 {name=l2231 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 5430 -220 0 0 {name=l2232 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 5430 -240 0 0 {name=l2233 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 5560 -900 1 0 {name=l2267 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5580 -900 1 0 {name=l2268 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 5600 -900 1 0 {name=l2269 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 5620 -900 1 0 {name=l2270 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 5650 -900 1 0 {name=l2271 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5670 -900 1 0 {name=l2272 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4990 -3650 0 0 {name=l491 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 5510 -3650 0 0 {name=l562 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 1830 -2750 0 0 {name=l633 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2350 -2750 0 0 {name=l704 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2890 -2750 0 0 {name=l775 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3410 -2750 0 0 {name=l846 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3930 -2750 0 0 {name=l917 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 4450 -2750 0 0 {name=l988 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 4990 -2750 0 0 {name=l1059 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 5510 -2750 0 0 {name=l1130 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 5520 -1800 0 0 {name=l1201 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 5000 -1800 0 0 {name=l1272 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 4460 -1800 0 0 {name=l1343 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3940 -1800 0 0 {name=l1414 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3420 -1800 0 0 {name=l1485 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2900 -1800 0 0 {name=l1556 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2360 -1800 0 0 {name=l1627 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 1840 -1800 0 0 {name=l1698 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 1840 -900 0 0 {name=l1769 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2360 -900 0 0 {name=l1840 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2900 -900 0 0 {name=l1911 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3420 -900 0 0 {name=l1982 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3940 -900 0 0 {name=l2053 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 4460 -900 0 0 {name=l2124 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 5000 -900 0 0 {name=l2195 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 5520 -900 0 0 {name=l2266 sig_type=std_logic lab=CLK_buf}
C {xschem_lib/DFFRAM_full_custom/dec_2to4.sym} 100 -3130 0 0 {name=x1 NF=2}
C {xschem_lib/DFFRAM_full_custom/dec_3to8.sym} 530 -3510 0 0 {name=x_dec1 NF=2}
C {xschem_lib/DFFRAM_full_custom/dec_3to8.sym} 530 -3260 0 0 {name=x_dec2 NF=2}
C {xschem_lib/DFFRAM_full_custom/dec_3to8.sym} 530 -3010 0 0 {name=x_dec3 NF=2}
C {xschem_lib/DFFRAM_full_custom/dec_3to8.sym} 530 -2750 0 0 {name=x_dec4 NF=2}
C {lab_wire.sym} 10 -3170 0 0 {name=l2273 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 10 -3150 0 0 {name=l2274 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 430 -3570 0 0 {name=l2275 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 430 -3550 0 0 {name=l2276 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 430 -3320 0 0 {name=l2277 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 430 -3300 0 0 {name=l2278 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 430 -3070 0 0 {name=l2279 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 430 -3050 0 0 {name=l2280 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 430 -2810 0 0 {name=l2281 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 430 -2790 0 0 {name=l2282 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 20 -2430 0 0 {name=X_inv1 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 180 -2430 0 0 {name=X_inv2 NF=8}
C {lab_wire.sym} 160 -2510 0 0 {name=l2283 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 160 -2430 0 0 {name=l2284 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 630 -3580 2 0 {name=l2285 sig_type=std_logic lab=Y0}
C {lab_wire.sym} 630 -3560 2 0 {name=l2286 sig_type=std_logic lab=Y1}
C {lab_wire.sym} 630 -3540 2 0 {name=l2287 sig_type=std_logic lab=Y2}
C {lab_wire.sym} 630 -3520 2 0 {name=l2288 sig_type=std_logic lab=Y3}
C {lab_wire.sym} 630 -3500 2 0 {name=l2289 sig_type=std_logic lab=Y4}
C {lab_wire.sym} 630 -3480 2 0 {name=l2290 sig_type=std_logic lab=Y5}
C {lab_wire.sym} 630 -3460 2 0 {name=l2291 sig_type=std_logic lab=Y6}
C {lab_wire.sym} 630 -3440 2 0 {name=l2292 sig_type=std_logic lab=Y7}
C {lab_wire.sym} 630 -3330 2 0 {name=l2293 sig_type=std_logic lab=Y8}
C {lab_wire.sym} 630 -3310 2 0 {name=l2294 sig_type=std_logic lab=Y9}
C {lab_wire.sym} 630 -3290 2 0 {name=l2295 sig_type=std_logic lab=Y10}
C {lab_wire.sym} 630 -3270 2 0 {name=l2296 sig_type=std_logic lab=Y11}
C {lab_wire.sym} 630 -3250 2 0 {name=l2297 sig_type=std_logic lab=Y12}
C {lab_wire.sym} 630 -3230 2 0 {name=l2298 sig_type=std_logic lab=Y13}
C {lab_wire.sym} 630 -3210 2 0 {name=l2299 sig_type=std_logic lab=Y14}
C {lab_wire.sym} 630 -3190 2 0 {name=l2300 sig_type=std_logic lab=Y15}
C {lab_wire.sym} 630 -3080 2 0 {name=l2301 sig_type=std_logic lab=Y16}
C {lab_wire.sym} 630 -3060 2 0 {name=l2302 sig_type=std_logic lab=Y17}
C {lab_wire.sym} 630 -3040 2 0 {name=l2303 sig_type=std_logic lab=Y18}
C {lab_wire.sym} 630 -3020 2 0 {name=l2304 sig_type=std_logic lab=Y19}
C {lab_wire.sym} 630 -3000 2 0 {name=l2305 sig_type=std_logic lab=Y20}
C {lab_wire.sym} 630 -2980 2 0 {name=l2306 sig_type=std_logic lab=Y21}
C {lab_wire.sym} 630 -2960 2 0 {name=l2307 sig_type=std_logic lab=Y22}
C {lab_wire.sym} 630 -2940 2 0 {name=l2308 sig_type=std_logic lab=Y23}
C {lab_wire.sym} 630 -2820 2 0 {name=l2309 sig_type=std_logic lab=Y24}
C {lab_wire.sym} 630 -2800 2 0 {name=l2310 sig_type=std_logic lab=Y25}
C {lab_wire.sym} 630 -2780 2 0 {name=l2311 sig_type=std_logic lab=Y26}
C {lab_wire.sym} 630 -2760 2 0 {name=l2312 sig_type=std_logic lab=Y27}
C {lab_wire.sym} 630 -2740 2 0 {name=l2313 sig_type=std_logic lab=Y28}
C {lab_wire.sym} 630 -2720 2 0 {name=l2314 sig_type=std_logic lab=Y29}
C {lab_wire.sym} 630 -2700 2 0 {name=l2315 sig_type=std_logic lab=Y30}
C {lab_wire.sym} 630 -2680 2 0 {name=l2316 sig_type=std_logic lab=Y31}
C {lab_wire.sym} 10 -2470 0 0 {name=l2317 sig_type=std_logic lab=Y0}
C {lab_wire.sym} 340 -2470 0 0 {name=l2318 sig_type=std_logic lab=SEL[0]}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 380 -2430 0 0 {name=X_inv3 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 540 -2430 0 0 {name=X_inv4 NF=8}
C {lab_wire.sym} 520 -2510 0 0 {name=l2319 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 520 -2430 0 0 {name=l2320 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 370 -2470 0 0 {name=l2321 sig_type=std_logic lab=Y1}
C {lab_wire.sym} 700 -2470 0 0 {name=l2322 sig_type=std_logic lab=SEL1}
C {lab_wire.sym} 900 -2510 0 0 {name=l2323 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 900 -2430 0 0 {name=l2324 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 750 -2470 0 0 {name=l2325 sig_type=std_logic lab=Y2}
C {lab_wire.sym} 1080 -2470 0 0 {name=l2326 sig_type=std_logic lab=SEL[2]}
C {lab_wire.sym} 1260 -2510 0 0 {name=l2327 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1260 -2430 0 0 {name=l2328 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1110 -2470 0 0 {name=l2329 sig_type=std_logic lab=Y3}
C {lab_wire.sym} 1440 -2470 0 0 {name=l2330 sig_type=std_logic lab=SEL[3]}
C {lab_wire.sym} 160 -2340 0 0 {name=l2331 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 160 -2260 0 0 {name=l2332 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 10 -2300 0 0 {name=l2333 sig_type=std_logic lab=Y4}
C {lab_wire.sym} 340 -2300 0 0 {name=l2334 sig_type=std_logic lab=SEL[4]}
C {lab_wire.sym} 520 -2340 0 0 {name=l2335 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 520 -2260 0 0 {name=l2336 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 370 -2300 0 0 {name=l2337 sig_type=std_logic lab=Y5}
C {lab_wire.sym} 700 -2300 0 0 {name=l2338 sig_type=std_logic lab=SEL[5]}
C {lab_wire.sym} 900 -2340 0 0 {name=l2339 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 900 -2260 0 0 {name=l2340 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 750 -2300 0 0 {name=l2341 sig_type=std_logic lab=Y6}
C {lab_wire.sym} 1080 -2300 0 0 {name=l2342 sig_type=std_logic lab=SEL[6]}
C {lab_wire.sym} 1260 -2340 0 0 {name=l2343 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1260 -2260 0 0 {name=l2344 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1110 -2300 0 0 {name=l2345 sig_type=std_logic lab=Y7}
C {lab_wire.sym} 1440 -2300 0 0 {name=l2346 sig_type=std_logic lab=SEL[7]}
C {lab_wire.sym} 150 -2170 0 0 {name=l2347 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 150 -2090 0 0 {name=l2348 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 0 -2130 0 0 {name=l2349 sig_type=std_logic lab=Y8}
C {lab_wire.sym} 330 -2130 0 0 {name=l2350 sig_type=std_logic lab=SEL[8]}
C {lab_wire.sym} 510 -2170 0 0 {name=l2351 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 510 -2090 0 0 {name=l2352 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 360 -2130 0 0 {name=l2353 sig_type=std_logic lab=Y9}
C {lab_wire.sym} 690 -2130 0 0 {name=l2354 sig_type=std_logic lab=SEL[9]}
C {lab_wire.sym} 890 -2170 0 0 {name=l2355 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 890 -2090 0 0 {name=l2356 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 740 -2130 0 0 {name=l2357 sig_type=std_logic lab=Y10}
C {lab_wire.sym} 1070 -2130 0 0 {name=l2358 sig_type=std_logic lab=SEL[10]}
C {lab_wire.sym} 1250 -2170 0 0 {name=l2359 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1250 -2090 0 0 {name=l2360 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1100 -2130 0 0 {name=l2361 sig_type=std_logic lab=Y11}
C {lab_wire.sym} 1430 -2130 0 0 {name=l2362 sig_type=std_logic lab=SEL[11]}
C {lab_wire.sym} 150 -2000 0 0 {name=l2363 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 150 -1920 0 0 {name=l2364 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 0 -1960 0 0 {name=l2365 sig_type=std_logic lab=Y12}
C {lab_wire.sym} 330 -1960 0 0 {name=l2366 sig_type=std_logic lab=SEL[12]}
C {lab_wire.sym} 510 -2000 0 0 {name=l2367 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 510 -1920 0 0 {name=l2368 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 360 -1960 0 0 {name=l2369 sig_type=std_logic lab=Y13}
C {lab_wire.sym} 690 -1960 0 0 {name=l2370 sig_type=std_logic lab=SEL[13]}
C {lab_wire.sym} 890 -2000 0 0 {name=l2371 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 890 -1920 0 0 {name=l2372 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 740 -1960 0 0 {name=l2373 sig_type=std_logic lab=Y14}
C {lab_wire.sym} 1070 -1960 0 0 {name=l2374 sig_type=std_logic lab=SEL[14]}
C {lab_wire.sym} 1250 -2000 0 0 {name=l2375 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1250 -1920 0 0 {name=l2376 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1100 -1960 0 0 {name=l2377 sig_type=std_logic lab=Y15}
C {lab_wire.sym} 1430 -1960 0 0 {name=l2378 sig_type=std_logic lab=SEL[15]}
C {lab_wire.sym} 160 -1830 0 0 {name=l2379 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 160 -1750 0 0 {name=l2380 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 10 -1790 0 0 {name=l2381 sig_type=std_logic lab=Y16}
C {lab_wire.sym} 340 -1790 0 0 {name=l2382 sig_type=std_logic lab=SEL[16]}
C {lab_wire.sym} 520 -1830 0 0 {name=l2383 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 520 -1750 0 0 {name=l2384 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 370 -1790 0 0 {name=l2385 sig_type=std_logic lab=Y17}
C {lab_wire.sym} 700 -1790 0 0 {name=l2386 sig_type=std_logic lab=SEL[17]}
C {lab_wire.sym} 900 -1830 0 0 {name=l2387 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 900 -1750 0 0 {name=l2388 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 750 -1790 0 0 {name=l2389 sig_type=std_logic lab=Y18}
C {lab_wire.sym} 1080 -1790 0 0 {name=l2390 sig_type=std_logic lab=SEL[18]}
C {lab_wire.sym} 1260 -1830 0 0 {name=l2391 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1260 -1750 0 0 {name=l2392 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1110 -1790 0 0 {name=l2393 sig_type=std_logic lab=Y19}
C {lab_wire.sym} 1440 -1790 0 0 {name=l2394 sig_type=std_logic lab=SEL[19]}
C {lab_wire.sym} 160 -1660 0 0 {name=l2395 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 160 -1580 0 0 {name=l2396 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 10 -1620 0 0 {name=l2397 sig_type=std_logic lab=Y20}
C {lab_wire.sym} 340 -1620 0 0 {name=l2398 sig_type=std_logic lab=SEL[20]}
C {lab_wire.sym} 520 -1660 0 0 {name=l2399 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 520 -1580 0 0 {name=l2400 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 370 -1620 0 0 {name=l2401 sig_type=std_logic lab=Y21}
C {lab_wire.sym} 700 -1620 0 0 {name=l2402 sig_type=std_logic lab=SEL[21]}
C {lab_wire.sym} 900 -1660 0 0 {name=l2403 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 900 -1580 0 0 {name=l2404 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 750 -1620 0 0 {name=l2405 sig_type=std_logic lab=Y22}
C {lab_wire.sym} 1080 -1620 0 0 {name=l2406 sig_type=std_logic lab=SEL[22]}
C {lab_wire.sym} 1260 -1660 0 0 {name=l2407 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1260 -1580 0 0 {name=l2408 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1110 -1620 0 0 {name=l2409 sig_type=std_logic lab=Y23}
C {lab_wire.sym} 1440 -1620 0 0 {name=l2410 sig_type=std_logic lab=SEL[23]}
C {lab_wire.sym} 160 -1490 0 0 {name=l2411 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 160 -1410 0 0 {name=l2412 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 10 -1450 0 0 {name=l2413 sig_type=std_logic lab=Y24}
C {lab_wire.sym} 340 -1450 0 0 {name=l2414 sig_type=std_logic lab=SEL[24]}
C {lab_wire.sym} 520 -1490 0 0 {name=l2415 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 520 -1410 0 0 {name=l2416 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 370 -1450 0 0 {name=l2417 sig_type=std_logic lab=Y25}
C {lab_wire.sym} 700 -1450 0 0 {name=l2418 sig_type=std_logic lab=SEL[25]}
C {lab_wire.sym} 900 -1490 0 0 {name=l2419 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 900 -1410 0 0 {name=l2420 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 750 -1450 0 0 {name=l2421 sig_type=std_logic lab=Y26}
C {lab_wire.sym} 1080 -1450 0 0 {name=l2422 sig_type=std_logic lab=SEL[26]}
C {lab_wire.sym} 1260 -1490 0 0 {name=l2423 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1260 -1410 0 0 {name=l2424 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1110 -1450 0 0 {name=l2425 sig_type=std_logic lab=Y27}
C {lab_wire.sym} 1440 -1450 0 0 {name=l2426 sig_type=std_logic lab=SEL[27]}
C {lab_wire.sym} 160 -1320 0 0 {name=l2427 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 160 -1240 0 0 {name=l2428 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 10 -1280 0 0 {name=l2429 sig_type=std_logic lab=Y28}
C {lab_wire.sym} 340 -1280 0 0 {name=l2430 sig_type=std_logic lab=SEL[28]}
C {lab_wire.sym} 520 -1320 0 0 {name=l2431 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 520 -1240 0 0 {name=l2432 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 370 -1280 0 0 {name=l2433 sig_type=std_logic lab=Y29}
C {lab_wire.sym} 700 -1280 0 0 {name=l2434 sig_type=std_logic lab=SEL[29]}
C {lab_wire.sym} 900 -1320 0 0 {name=l2435 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 900 -1240 0 0 {name=l2436 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 750 -1280 0 0 {name=l2437 sig_type=std_logic lab=Y30}
C {lab_wire.sym} 1080 -1280 0 0 {name=l2438 sig_type=std_logic lab=SEL[30]}
C {lab_wire.sym} 1260 -1320 0 0 {name=l2439 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1260 -1240 0 0 {name=l2440 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1110 -1280 0 0 {name=l2441 sig_type=std_logic lab=Y31}
C {lab_wire.sym} 1440 -1280 0 0 {name=l2442 sig_type=std_logic lab=SEL[31]}
C {lab_wire.sym} 1850 -2750 1 0 {name=l2443 sig_type=std_logic lab=SEL[8]}
C {lab_wire.sym} 1850 -3650 1 0 {name=l2444 sig_type=std_logic lab=SEL[0]}
C {lab_wire.sym} 1860 -1800 1 0 {name=l2445 sig_type=std_logic lab=SEL[16]}
C {lab_wire.sym} 1860 -900 1 0 {name=l2446 sig_type=std_logic lab=SEL[24]}
C {lab_wire.sym} 2390 -3650 1 0 {name=l2447 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 2390 -2750 1 0 {name=l2448 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 2370 -2750 1 0 {name=l2449 sig_type=std_logic lab=SEL[9]}
C {lab_wire.sym} 2370 -3650 1 0 {name=l2450 sig_type=std_logic lab=SEL1}
C {lab_wire.sym} 2380 -1800 1 0 {name=l2451 sig_type=std_logic lab=SEL[17]}
C {lab_wire.sym} 2380 -900 1 0 {name=l2452 sig_type=std_logic lab=SEL[25]}
C {lab_wire.sym} 2930 -3650 1 0 {name=l2453 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 2930 -2750 1 0 {name=l2454 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 2910 -2750 1 0 {name=l2455 sig_type=std_logic lab=SEL[10]}
C {lab_wire.sym} 2910 -3650 1 0 {name=l2456 sig_type=std_logic lab=SEL[2]}
C {lab_wire.sym} 2920 -1800 1 0 {name=l2457 sig_type=std_logic lab=SEL[18]}
C {lab_wire.sym} 2920 -900 1 0 {name=l2458 sig_type=std_logic lab=SEL[26]}
C {lab_wire.sym} 3450 -3650 1 0 {name=l2459 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 3450 -2750 1 0 {name=l2460 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 3430 -2750 1 0 {name=l2461 sig_type=std_logic lab=SEL[11]}
C {lab_wire.sym} 3430 -3650 1 0 {name=l2462 sig_type=std_logic lab=SEL[3]}
C {lab_wire.sym} 3440 -1800 1 0 {name=l2463 sig_type=std_logic lab=SEL[19]}
C {lab_wire.sym} 3440 -900 1 0 {name=l2464 sig_type=std_logic lab=SEL[27]}
C {lab_wire.sym} 3970 -3650 1 0 {name=l2465 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 3970 -2750 1 0 {name=l2466 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 3950 -2750 1 0 {name=l2467 sig_type=std_logic lab=SEL[12]}
C {lab_wire.sym} 3950 -3650 1 0 {name=l2468 sig_type=std_logic lab=SEL[4]}
C {lab_wire.sym} 3960 -1800 1 0 {name=l2469 sig_type=std_logic lab=SEL[20]}
C {lab_wire.sym} 3960 -900 1 0 {name=l2470 sig_type=std_logic lab=SEL[28]}
C {lab_wire.sym} 4490 -3650 1 0 {name=l2471 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 4490 -2750 1 0 {name=l2472 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 4470 -2750 1 0 {name=l2473 sig_type=std_logic lab=SEL[13]}
C {lab_wire.sym} 4470 -3650 1 0 {name=l2474 sig_type=std_logic lab=SEL[5]}
C {lab_wire.sym} 4480 -1800 1 0 {name=l2475 sig_type=std_logic lab=SEL[21]}
C {lab_wire.sym} 4480 -900 1 0 {name=l2476 sig_type=std_logic lab=SEL[29]}
C {lab_wire.sym} 5030 -3650 1 0 {name=l2477 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5030 -2750 1 0 {name=l2478 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5010 -2750 1 0 {name=l2479 sig_type=std_logic lab=SEL[14]}
C {lab_wire.sym} 5010 -3650 1 0 {name=l2480 sig_type=std_logic lab=SEL[6]}
C {lab_wire.sym} 5020 -1800 1 0 {name=l2481 sig_type=std_logic lab=SEL[22]}
C {lab_wire.sym} 5020 -900 1 0 {name=l2482 sig_type=std_logic lab=SEL[30]}
C {lab_wire.sym} 5550 -3650 1 0 {name=l2483 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5550 -2750 1 0 {name=l2484 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5530 -2750 1 0 {name=l2485 sig_type=std_logic lab=SEL[15]}
C {lab_wire.sym} 5530 -3650 1 0 {name=l2486 sig_type=std_logic lab=SEL[7]}
C {lab_wire.sym} 5540 -1800 1 0 {name=l2487 sig_type=std_logic lab=SEL[23]}
C {lab_wire.sym} 5540 -900 1 0 {name=l2488 sig_type=std_logic lab=SEL[31]}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 10 -3780 0 0 {name=X_inv65 NF=8}
C {lab_wire.sym} 70 -3870 0 0 {name=l2489 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 70 -3770 2 0 {name=l2490 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -190 -3820 0 0 {name=l2491 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 560 -3820 2 0 {name=l2492 sig_type=std_logic lab=CLK_buf}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 840 -2890 0 0 {name=X_inv67 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1000 -2890 0 0 {name=X_inv68 NF=16}
C {lab_wire.sym} 980 -2970 0 0 {name=l2493 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 980 -2890 0 0 {name=l2494 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 830 -2930 0 0 {name=l2495 sig_type=std_logic lab=WE3}
C {lab_wire.sym} 1160 -2930 0 0 {name=l2496 sig_type=std_logic lab=we3_buf}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 840 -3010 0 0 {name=X_inv69 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1000 -3010 0 0 {name=X_inv70 NF=16}
C {lab_wire.sym} 980 -3090 0 0 {name=l2497 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 980 -3010 0 0 {name=l2498 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 830 -3050 0 0 {name=l2499 sig_type=std_logic lab=WE2}
C {lab_wire.sym} 1160 -3050 0 0 {name=l2500 sig_type=std_logic lab=we2_buf}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 840 -3140 0 0 {name=X_inv71 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1000 -3140 0 0 {name=X_inv72 NF=16}
C {lab_wire.sym} 980 -3220 0 0 {name=l2501 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 980 -3140 0 0 {name=l2502 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 830 -3180 0 0 {name=l2503 sig_type=std_logic lab=WE1}
C {lab_wire.sym} 1160 -3180 0 0 {name=l2504 sig_type=std_logic lab=we1_buf}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 840 -3260 0 0 {name=X_inv73 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1000 -3260 0 0 {name=X_inv74 NF=16}
C {lab_wire.sym} 980 -3340 0 0 {name=l2505 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 980 -3260 0 0 {name=l2506 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 830 -3300 0 0 {name=l2507 sig_type=std_logic lab=WE0}
C {lab_wire.sym} 1160 -3300 0 0 {name=l2508 sig_type=std_logic lab=we0_buf}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 20 -950 0 0 {name=X_inv75 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 180 -950 0 0 {name=X_inv76 NF=16}
C {lab_wire.sym} 160 -1030 0 0 {name=l2509 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 160 -950 0 0 {name=l2510 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -10 -990 0 0 {name=l2511 sig_type=std_logic lab=Di0}
C {lab_wire.sym} 340 -990 0 0 {name=l2512 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 400 -990 0 0 {name=l2515 sig_type=std_logic lab=Di1}
C {lab_wire.sym} 740 -990 0 0 {name=l2516 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 800 -990 0 0 {name=l2519 sig_type=std_logic lab=Di2}
C {lab_wire.sym} 1140 -990 0 0 {name=l2520 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 1200 -990 0 0 {name=l2523 sig_type=std_logic lab=Di3}
C {lab_wire.sym} 1540 -990 0 0 {name=l2524 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 160 -900 0 0 {name=l2525 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 160 -820 0 0 {name=l2526 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -10 -860 0 0 {name=l2527 sig_type=std_logic lab=Di4}
C {lab_wire.sym} 340 -860 0 0 {name=l2528 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 400 -860 0 0 {name=l2531 sig_type=std_logic lab=Di5}
C {lab_wire.sym} 740 -860 0 0 {name=l2532 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 800 -860 0 0 {name=l2535 sig_type=std_logic lab=Di6}
C {lab_wire.sym} 1140 -860 0 0 {name=l2536 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 1200 -860 0 0 {name=l2539 sig_type=std_logic lab=Di7}
C {lab_wire.sym} 1540 -860 0 0 {name=l2540 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 160 -770 0 0 {name=l2541 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 160 -690 0 0 {name=l2542 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -10 -730 0 0 {name=l2543 sig_type=std_logic lab=Di8}
C {lab_wire.sym} 340 -730 0 0 {name=l2544 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 400 -730 0 0 {name=l2547 sig_type=std_logic lab=Di9}
C {lab_wire.sym} 740 -730 0 0 {name=l2548 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 800 -730 0 0 {name=l2551 sig_type=std_logic lab=Di10}
C {lab_wire.sym} 1140 -730 0 0 {name=l2552 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 1200 -730 0 0 {name=l2555 sig_type=std_logic lab=Di11}
C {lab_wire.sym} 1540 -730 0 0 {name=l2556 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 160 -640 0 0 {name=l2557 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 160 -560 0 0 {name=l2558 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -10 -600 0 0 {name=l2559 sig_type=std_logic lab=Di12}
C {lab_wire.sym} 340 -600 0 0 {name=l2560 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 400 -600 0 0 {name=l2563 sig_type=std_logic lab=Di13}
C {lab_wire.sym} 740 -600 0 0 {name=l2564 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 800 -600 0 0 {name=l2567 sig_type=std_logic lab=Di14}
C {lab_wire.sym} 1140 -600 0 0 {name=l2568 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 1200 -600 0 0 {name=l2571 sig_type=std_logic lab=Di15}
C {lab_wire.sym} 1540 -600 0 0 {name=l2572 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 160 -510 0 0 {name=l2573 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 160 -430 0 0 {name=l2574 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -10 -470 0 0 {name=l2575 sig_type=std_logic lab=Di16}
C {lab_wire.sym} 340 -470 0 0 {name=l2576 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 400 -470 0 0 {name=l2579 sig_type=std_logic lab=Di17}
C {lab_wire.sym} 740 -470 0 0 {name=l2580 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 800 -470 0 0 {name=l2583 sig_type=std_logic lab=Di18}
C {lab_wire.sym} 1140 -470 0 0 {name=l2584 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 1200 -470 0 0 {name=l2587 sig_type=std_logic lab=Di19}
C {lab_wire.sym} 1540 -470 0 0 {name=l2588 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 160 -380 0 0 {name=l2589 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 160 -300 0 0 {name=l2590 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -10 -340 0 0 {name=l2591 sig_type=std_logic lab=Di20}
C {lab_wire.sym} 340 -340 0 0 {name=l2592 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 400 -340 0 0 {name=l2595 sig_type=std_logic lab=Di21}
C {lab_wire.sym} 740 -340 0 0 {name=l2596 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 800 -340 0 0 {name=l2599 sig_type=std_logic lab=Di22}
C {lab_wire.sym} 1140 -340 0 0 {name=l2600 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 1200 -340 0 0 {name=l2603 sig_type=std_logic lab=Di23}
C {lab_wire.sym} 1540 -340 0 0 {name=l2604 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 160 -250 0 0 {name=l2605 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 160 -170 0 0 {name=l2606 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -10 -210 0 0 {name=l2607 sig_type=std_logic lab=Di24}
C {lab_wire.sym} 340 -210 0 0 {name=l2608 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 400 -210 0 0 {name=l2611 sig_type=std_logic lab=Di25}
C {lab_wire.sym} 740 -210 0 0 {name=l2612 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 800 -210 0 0 {name=l2615 sig_type=std_logic lab=Di26}
C {lab_wire.sym} 1140 -210 0 0 {name=l2616 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 1200 -210 0 0 {name=l2619 sig_type=std_logic lab=Di27}
C {lab_wire.sym} 1540 -210 0 0 {name=l2620 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 160 -120 0 0 {name=l2621 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 160 -40 0 0 {name=l2622 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -10 -80 0 0 {name=l2623 sig_type=std_logic lab=Di28}
C {lab_wire.sym} 340 -80 0 0 {name=l2624 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 400 -80 0 0 {name=l2627 sig_type=std_logic lab=Di29}
C {lab_wire.sym} 740 -80 0 0 {name=l2628 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 800 -80 0 0 {name=l2631 sig_type=std_logic lab=Di30}
C {lab_wire.sym} 1140 -80 0 0 {name=l2632 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 1200 -80 0 0 {name=l2635 sig_type=std_logic lab=Di31}
C {lab_wire.sym} 1540 -80 0 0 {name=l2636 sig_type=std_logic lab=Di[31]}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 200 -3780 0 0 {name=X_inv139 NF=16}
C {lab_wire.sym} 260 -3870 0 0 {name=l2639 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 260 -3770 2 0 {name=l2640 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -180 -3780 0 0 {name=X_inv143 NF=2}
C {lab_wire.sym} -120 -3870 0 0 {name=l2647 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -120 -3770 2 0 {name=l2648 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 380 -3780 0 0 {name=X_inv66 NF=32}
C {lab_wire.sym} 440 -3870 0 0 {name=l2637 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 440 -3770 2 0 {name=l2638 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 0 -3130 0 0 {name=l2641 sig_type=std_logic lab=A3}
C {lab_pin.sym} 0 -3110 0 0 {name=l2642 sig_type=std_logic lab=A4}
C {lab_pin.sym} 0 -3090 0 0 {name=l2643 sig_type=std_logic lab=EN}
C {lab_pin.sym} 0 -2990 0 0 {name=l2644 sig_type=std_logic lab=A2}
C {lab_pin.sym} 0 -2970 0 0 {name=l2645 sig_type=std_logic lab=A1}
C {lab_pin.sym} 0 -2950 0 0 {name=l2646 sig_type=std_logic lab=A0}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 20 -2260 0 0 {name=X_inv9 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 10 -2090 0 0 {name=X_inv17 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 10 -1920 0 0 {name=X_inv25 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 20 -1750 0 0 {name=X_inv33 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 20 -1580 0 0 {name=X_inv41 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 20 -1410 0 0 {name=X_inv49 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 20 -1240 0 0 {name=X_inv57 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 180 -2260 0 0 {name=X_inv10 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 170 -2090 0 0 {name=X_inv18 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 170 -1920 0 0 {name=X_inv26 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 180 -1750 0 0 {name=X_inv34 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 180 -1580 0 0 {name=X_inv42 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 180 -1410 0 0 {name=X_inv50 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 180 -1240 0 0 {name=X_inv58 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 380 -2260 0 0 {name=X_inv11 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 370 -2090 0 0 {name=X_inv12 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 370 -1920 0 0 {name=X_inv19 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 380 -1750 0 0 {name=X_inv20 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 380 -1580 0 0 {name=X_inv27 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 380 -1410 0 0 {name=X_inv28 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 380 -1240 0 0 {name=X_inv35 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 540 -2260 0 0 {name=X_inv36 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 530 -2090 0 0 {name=X_inv43 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 530 -1920 0 0 {name=X_inv44 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 540 -1750 0 0 {name=X_inv51 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 540 -1580 0 0 {name=X_inv52 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 540 -1410 0 0 {name=X_inv59 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 540 -1240 0 0 {name=X_inv60 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 760 -2430 0 0 {name=X_inv5 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 760 -2260 0 0 {name=X_inv13 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 750 -2090 0 0 {name=X_inv21 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 750 -1920 0 0 {name=X_inv29 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 760 -1750 0 0 {name=X_inv37 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 760 -1580 0 0 {name=X_inv45 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 760 -1410 0 0 {name=X_inv53 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 760 -1240 0 0 {name=X_inv61 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 920 -2430 0 0 {name=X_inv6 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 920 -2260 0 0 {name=X_inv14 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 910 -2090 0 0 {name=X_inv22 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 910 -1920 0 0 {name=X_inv30 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 920 -1750 0 0 {name=X_inv38 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 920 -1580 0 0 {name=X_inv46 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 920 -1410 0 0 {name=X_inv54 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 920 -1240 0 0 {name=X_inv62 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1120 -2430 0 0 {name=X_inv7 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1120 -2260 0 0 {name=X_inv15 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1110 -2090 0 0 {name=X_inv23 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1110 -1920 0 0 {name=X_inv31 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1120 -1750 0 0 {name=X_inv39 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1120 -1580 0 0 {name=X_inv47 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1120 -1410 0 0 {name=X_inv55 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1120 -1240 0 0 {name=X_inv63 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1280 -2430 0 0 {name=X_inv8 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1280 -2260 0 0 {name=X_inv16 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1270 -2090 0 0 {name=X_inv24 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1270 -1920 0 0 {name=X_inv32 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1280 -1750 0 0 {name=X_inv40 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1280 -1580 0 0 {name=X_inv48 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1280 -1410 0 0 {name=X_inv56 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1280 -1240 0 0 {name=X_inv64 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 20 -820 0 0 {name=X_inv83 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 20 -690 0 0 {name=X_inv91 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 20 -560 0 0 {name=X_inv99 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 20 -430 0 0 {name=X_inv107 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 20 -300 0 0 {name=X_inv115 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 20 -170 0 0 {name=X_inv123 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 20 -40 0 0 {name=X_inv131 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 180 -820 0 0 {name=X_inv84 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 180 -690 0 0 {name=X_inv92 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 180 -560 0 0 {name=X_inv100 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 180 -430 0 0 {name=X_inv108 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 180 -300 0 0 {name=X_inv116 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 180 -170 0 0 {name=X_inv124 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 180 -40 0 0 {name=X_inv132 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 420 -950 0 0 {name=X_inv77 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 580 -950 0 0 {name=X_inv78 NF=16}
C {lab_wire.sym} 560 -1030 0 0 {name=l2513 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 560 -950 0 0 {name=l2514 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 560 -900 0 0 {name=l2529 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 560 -820 0 0 {name=l2530 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 560 -770 0 0 {name=l2545 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 560 -690 0 0 {name=l2546 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 560 -640 0 0 {name=l2561 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 560 -560 0 0 {name=l2562 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 560 -510 0 0 {name=l2577 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 560 -430 0 0 {name=l2578 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 560 -380 0 0 {name=l2593 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 560 -300 0 0 {name=l2594 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 560 -250 0 0 {name=l2609 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 560 -170 0 0 {name=l2610 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 560 -120 0 0 {name=l2625 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 560 -40 0 0 {name=l2626 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 420 -820 0 0 {name=X_inv85 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 420 -690 0 0 {name=X_inv86 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 420 -560 0 0 {name=X_inv93 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 420 -430 0 0 {name=X_inv94 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 420 -300 0 0 {name=X_inv101 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 420 -170 0 0 {name=X_inv102 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 420 -40 0 0 {name=X_inv109 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 580 -820 0 0 {name=X_inv110 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 580 -690 0 0 {name=X_inv117 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 580 -560 0 0 {name=X_inv118 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 580 -430 0 0 {name=X_inv125 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 580 -300 0 0 {name=X_inv126 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 580 -170 0 0 {name=X_inv133 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 580 -40 0 0 {name=X_inv134 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 820 -950 0 0 {name=X_inv79 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 980 -950 0 0 {name=X_inv80 NF=16}
C {lab_wire.sym} 960 -1030 0 0 {name=l2517 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 960 -950 0 0 {name=l2518 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 960 -900 0 0 {name=l2521 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 960 -820 0 0 {name=l2522 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 960 -770 0 0 {name=l2533 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 960 -690 0 0 {name=l2534 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 960 -640 0 0 {name=l2537 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 960 -560 0 0 {name=l2538 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 960 -510 0 0 {name=l2549 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 960 -430 0 0 {name=l2550 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 960 -380 0 0 {name=l2553 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 960 -300 0 0 {name=l2554 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 960 -250 0 0 {name=l2565 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 960 -170 0 0 {name=l2566 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 960 -120 0 0 {name=l2569 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 960 -40 0 0 {name=l2570 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 820 -820 0 0 {name=X_inv81 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 820 -690 0 0 {name=X_inv82 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 820 -560 0 0 {name=X_inv87 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 820 -430 0 0 {name=X_inv88 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 820 -300 0 0 {name=X_inv89 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 820 -170 0 0 {name=X_inv90 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 820 -40 0 0 {name=X_inv95 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 980 -820 0 0 {name=X_inv96 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 980 -690 0 0 {name=X_inv97 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 980 -560 0 0 {name=X_inv98 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 980 -430 0 0 {name=X_inv103 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 980 -300 0 0 {name=X_inv104 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 980 -170 0 0 {name=X_inv105 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 980 -40 0 0 {name=X_inv106 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1220 -950 0 0 {name=X_inv111 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1380 -950 0 0 {name=X_inv112 NF=16}
C {lab_wire.sym} 1360 -1030 0 0 {name=l2581 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1360 -950 0 0 {name=l2582 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1360 -900 0 0 {name=l2585 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1360 -820 0 0 {name=l2586 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1360 -770 0 0 {name=l2597 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1360 -690 0 0 {name=l2598 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1360 -640 0 0 {name=l2601 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1360 -560 0 0 {name=l2602 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1360 -510 0 0 {name=l2613 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1360 -430 0 0 {name=l2614 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1360 -380 0 0 {name=l2617 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1360 -300 0 0 {name=l2618 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1360 -250 0 0 {name=l2629 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1360 -170 0 0 {name=l2630 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1360 -120 0 0 {name=l2633 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1360 -40 0 0 {name=l2634 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1220 -820 0 0 {name=X_inv113 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1220 -690 0 0 {name=X_inv114 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1220 -560 0 0 {name=X_inv119 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1220 -430 0 0 {name=X_inv120 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1220 -300 0 0 {name=X_inv121 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1220 -170 0 0 {name=X_inv122 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1220 -40 0 0 {name=X_inv127 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1380 -820 0 0 {name=X_inv128 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1380 -690 0 0 {name=X_inv129 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1380 -560 0 0 {name=X_inv130 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1380 -430 0 0 {name=X_inv135 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1380 -300 0 0 {name=X_inv136 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1380 -170 0 0 {name=X_inv137 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1380 -40 0 0 {name=X_inv138 NF=16}
C {gnd.sym} -1000 -3560 0 0 {name=l2649 lab=GND}
C {lab_pin.sym} -1000 -3620 0 0 {name=l2650 sig_type=std_logic lab=CLK}
C {vsource.sym} -1000 -3470 0 0 {name=V2 value=3.3}
C {gnd.sym} -1000 -3440 0 0 {name=l2651 lab=GND}
C {lab_pin.sym} -1000 -3500 0 0 {name=l2652 sig_type=std_logic lab=VDD}
C {vsource.sym} -920 -3470 0 0 {name=V3 value=0}
C {gnd.sym} -920 -3440 0 0 {name=l2653 lab=GND}
C {lab_pin.sym} -920 -3500 0 0 {name=l2654 sig_type=std_logic lab=VSS}
C {gnd.sym} -750 -3360 0 0 {name=l2655 lab=GND}
C {lab_pin.sym} -750 -3420 0 0 {name=l2656 sig_type=std_logic lab=A2}
C {gnd.sym} -750 -3540 0 0 {name=l2657 lab=GND}
C {lab_pin.sym} -750 -3600 0 0 {name=l2658 sig_type=std_logic lab=A0}
C {gnd.sym} -750 -3450 0 0 {name=l2659 lab=GND}
C {lab_pin.sym} -750 -3510 0 0 {name=l2660 sig_type=std_logic lab=A1}
C {gnd.sym} -520 -3450 0 0 {name=l2661 lab=GND}
C {lab_pin.sym} -520 -3510 0 0 {name=l2662 sig_type=std_logic lab=A4}
C {gnd.sym} -520 -3540 0 0 {name=l2663 lab=GND}
C {lab_pin.sym} -520 -3600 0 0 {name=l2664 sig_type=std_logic lab=A3}
C {gnd.sym} -520 -3360 0 0 {name=l2665 lab=GND}
C {lab_pin.sym} -520 -3420 0 0 {name=l2666 sig_type=std_logic lab=EN}
C {gnd.sym} -760 -3690 0 0 {name=l2667 lab=GND}
C {lab_pin.sym} -760 -3750 0 0 {name=l2668 sig_type=std_logic lab=Di3}
C {gnd.sym} -760 -3960 0 0 {name=l2669 lab=GND}
C {lab_pin.sym} -760 -4020 0 0 {name=l2670 sig_type=std_logic lab=Di0}
C {gnd.sym} -760 -3780 0 0 {name=l2671 lab=GND}
C {lab_pin.sym} -760 -3840 0 0 {name=l2672 sig_type=std_logic lab=Di2}
C {gnd.sym} -530 -3870 0 0 {name=l2673 lab=GND}
C {lab_pin.sym} -530 -3930 0 0 {name=l2674 sig_type=std_logic lab=Di5}
C {gnd.sym} -530 -3960 0 0 {name=l2675 lab=GND}
C {lab_pin.sym} -530 -4020 0 0 {name=l2676 sig_type=std_logic lab=Di4}
C {gnd.sym} -530 -3780 0 0 {name=l2679 lab=GND}
C {lab_pin.sym} -530 -3840 0 0 {name=l2680 sig_type=std_logic lab=Di6}
C {gnd.sym} -530 -3690 0 0 {name=l2681 lab=GND}
C {lab_pin.sym} -530 -3750 0 0 {name=l2682 sig_type=std_logic lab=Di7}
C {gnd.sym} -760 -3870 0 0 {name=l2677 lab=GND}
C {lab_pin.sym} -760 -3930 0 0 {name=l2678 sig_type=std_logic lab=Di1}
C {vsource.sym} -1000 -3590 0 0 {name=V18 value="PULSE(0V 3.3 2n 50p 50p 2n 4n)"}
C {vsource.sym} -760 -3990 0 0 {name=V10 value="PULSE(0V 3.3 0n 50p 50p 4n 8n)"}
C {vsource.sym} -750 -3570 0 0 {name=V4 value="PULSE(0V 3.3 8n 50p 50p 8n 16n)"}
C {vsource.sym} -750 -3480 0 0 {name=V5 value=0}
C {vsource.sym} -750 -3390 0 0 {name=V6 value=0}
C {vsource.sym} -520 -3480 0 0 {name=V8 value=0}
C {vsource.sym} -520 -3570 0 0 {name=V9 value=0}
C {vsource.sym} -760 -3900 0 0 {name=V1 value="PULSE(0V 3.3 0n 50p 50p 4n 8n)"}
C {vsource.sym} -760 -3810 0 0 {name=V11 value="PULSE(0V 3.3 0n 50p 50p 4n 8n)"}
C {vsource.sym} -760 -3720 0 0 {name=V12 value="PULSE(0V 3.3 0n 50p 50p 4n 8n)"}
C {vsource.sym} -530 -3720 0 0 {name=V13 value="PULSE(0V 3.3 0n 50p 50p 4n 8n)"}
C {vsource.sym} -530 -3810 0 0 {name=V14 value="PULSE(0V 3.3 0n 50p 50p 4n 8n)"}
C {vsource.sym} -530 -3900 0 0 {name=V15 value="PULSE(0V 3.3 0n 50p 50p 4n 8n)"}
C {vsource.sym} -530 -3990 0 0 {name=V16 value="PULSE(0V 3.3 0n 50p 50p 4n 8n)"}
C {vsource.sym} -520 -3390 0 0 {name=V7 value="PULSE(0V 3.3 8n 50p 50p 8n 16n)"}
C {gnd.sym} -1000 -3950 0 0 {name=l2695 lab=GND}
C {lab_pin.sym} -1000 -4010 0 0 {name=l2696 sig_type=std_logic lab=WE0}
C {vsource.sym} -1000 -3980 0 0 {name=V24 value="PULSE(0V 3.3 8n 50p 50p 8n 16n)"}
C {gnd.sym} -1000 -3670 0 0 {name=l2697 lab=GND}
C {lab_pin.sym} -1000 -3730 0 0 {name=l2698 sig_type=std_logic lab=WE3}
C {gnd.sym} -1000 -3860 0 0 {name=l2699 lab=GND}
C {lab_pin.sym} -1000 -3920 0 0 {name=l2700 sig_type=std_logic lab=WE1}
C {vsource.sym} -1000 -3890 0 0 {name=V25 value=0}
C {vsource.sym} -1000 -3700 0 0 {name=V26 value=0}
C {gnd.sym} -1000 -3760 0 0 {name=l2689 lab=GND}
C {lab_pin.sym} -1000 -3820 0 0 {name=l2690 sig_type=std_logic lab=WE2}
C {vsource.sym} -1000 -3790 0 0 {name=V21 value=0}
C {lab_wire.sym} 2600 -3590 2 0 {name=l104 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 2600 -3570 2 0 {name=l105 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 2600 -3550 2 0 {name=l106 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 2600 -3530 2 0 {name=l107 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 2600 -3510 2 0 {name=l108 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 2600 -3490 2 0 {name=l109 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 2600 -3470 2 0 {name=l110 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 2600 -3450 2 0 {name=l111 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 2600 -3430 2 0 {name=l112 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 2600 -3410 2 0 {name=l113 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 2600 -3390 2 0 {name=l114 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 2600 -3370 2 0 {name=l115 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 2600 -3350 2 0 {name=l116 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 2600 -3330 2 0 {name=l117 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 2600 -3310 2 0 {name=l118 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 2600 -3290 2 0 {name=l119 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 2600 -3270 2 0 {name=l120 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 2600 -3250 2 0 {name=l121 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 2600 -3230 2 0 {name=l122 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 2600 -3210 2 0 {name=l123 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 2600 -3190 2 0 {name=l124 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 2600 -3170 2 0 {name=l125 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 2600 -3150 2 0 {name=l126 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 2600 -3130 2 0 {name=l127 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 2600 -3110 2 0 {name=l128 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 2600 -3090 2 0 {name=l129 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 2600 -3070 2 0 {name=l130 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 2600 -3050 2 0 {name=l131 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 2600 -3030 2 0 {name=l132 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 2600 -3010 2 0 {name=l133 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 2600 -2990 2 0 {name=l134 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 2600 -2970 2 0 {name=l135 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 3140 -3590 2 0 {name=l175 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 3140 -3570 2 0 {name=l176 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 3140 -3550 2 0 {name=l177 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 3140 -3530 2 0 {name=l178 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 3140 -3510 2 0 {name=l179 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 3140 -3490 2 0 {name=l180 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 3140 -3470 2 0 {name=l181 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 3140 -3450 2 0 {name=l182 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 3140 -3430 2 0 {name=l183 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 3140 -3410 2 0 {name=l184 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 3140 -3390 2 0 {name=l185 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 3140 -3370 2 0 {name=l186 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 3140 -3350 2 0 {name=l187 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 3140 -3330 2 0 {name=l188 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 3140 -3310 2 0 {name=l189 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 3140 -3290 2 0 {name=l190 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 3140 -3270 2 0 {name=l191 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 3140 -3250 2 0 {name=l192 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 3140 -3230 2 0 {name=l193 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 3140 -3210 2 0 {name=l194 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 3140 -3190 2 0 {name=l195 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 3140 -3170 2 0 {name=l196 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 3140 -3150 2 0 {name=l197 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 3140 -3130 2 0 {name=l198 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 3140 -3110 2 0 {name=l199 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 3140 -3090 2 0 {name=l200 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 3140 -3070 2 0 {name=l201 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 3140 -3050 2 0 {name=l202 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 3140 -3030 2 0 {name=l203 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 3140 -3010 2 0 {name=l204 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 3140 -2990 2 0 {name=l205 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 3140 -2970 2 0 {name=l206 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 3660 -3590 2 0 {name=l246 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 3660 -3570 2 0 {name=l247 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 3660 -3550 2 0 {name=l248 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 3660 -3530 2 0 {name=l249 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 3660 -3510 2 0 {name=l250 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 3660 -3490 2 0 {name=l251 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 3660 -3470 2 0 {name=l252 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 3660 -3450 2 0 {name=l253 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 3660 -3430 2 0 {name=l254 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 3660 -3410 2 0 {name=l255 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 3660 -3390 2 0 {name=l256 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 3660 -3370 2 0 {name=l257 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 3660 -3350 2 0 {name=l258 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 3660 -3330 2 0 {name=l259 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 3660 -3310 2 0 {name=l260 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 3660 -3290 2 0 {name=l261 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 3660 -3270 2 0 {name=l262 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 3660 -3250 2 0 {name=l263 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 3660 -3230 2 0 {name=l264 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 3660 -3210 2 0 {name=l265 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 3660 -3190 2 0 {name=l266 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 3660 -3170 2 0 {name=l267 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 3660 -3150 2 0 {name=l268 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 3660 -3130 2 0 {name=l269 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 3660 -3110 2 0 {name=l270 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 3660 -3090 2 0 {name=l271 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 3660 -3070 2 0 {name=l272 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 3660 -3050 2 0 {name=l273 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 3660 -3030 2 0 {name=l274 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 3660 -3010 2 0 {name=l275 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 3660 -2990 2 0 {name=l276 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 3660 -2970 2 0 {name=l277 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 4180 -3590 2 0 {name=l317 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 4180 -3570 2 0 {name=l318 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 4180 -3550 2 0 {name=l319 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 4180 -3530 2 0 {name=l320 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 4180 -3510 2 0 {name=l321 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 4180 -3490 2 0 {name=l322 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 4180 -3470 2 0 {name=l323 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 4180 -3450 2 0 {name=l324 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 4180 -3430 2 0 {name=l325 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 4180 -3410 2 0 {name=l326 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 4180 -3390 2 0 {name=l327 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 4180 -3370 2 0 {name=l328 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 4180 -3350 2 0 {name=l329 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 4180 -3330 2 0 {name=l330 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 4180 -3310 2 0 {name=l331 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 4180 -3290 2 0 {name=l332 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 4180 -3270 2 0 {name=l333 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 4180 -3250 2 0 {name=l334 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 4180 -3230 2 0 {name=l335 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 4180 -3210 2 0 {name=l336 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 4180 -3190 2 0 {name=l337 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 4180 -3170 2 0 {name=l338 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 4180 -3150 2 0 {name=l339 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 4180 -3130 2 0 {name=l340 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 4180 -3110 2 0 {name=l341 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 4180 -3090 2 0 {name=l342 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 4180 -3070 2 0 {name=l343 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 4180 -3050 2 0 {name=l344 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 4180 -3030 2 0 {name=l345 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 4180 -3010 2 0 {name=l346 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 4180 -2990 2 0 {name=l347 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 4180 -2970 2 0 {name=l348 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 4700 -3590 2 0 {name=l388 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 4700 -3570 2 0 {name=l389 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 4700 -3550 2 0 {name=l390 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 4700 -3530 2 0 {name=l391 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 4700 -3510 2 0 {name=l392 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 4700 -3490 2 0 {name=l393 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 4700 -3470 2 0 {name=l394 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 4700 -3450 2 0 {name=l395 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 4700 -3430 2 0 {name=l396 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 4700 -3410 2 0 {name=l397 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 4700 -3390 2 0 {name=l398 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 4700 -3370 2 0 {name=l399 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 4700 -3350 2 0 {name=l400 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 4700 -3330 2 0 {name=l401 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 4700 -3310 2 0 {name=l402 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 4700 -3290 2 0 {name=l403 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 4700 -3270 2 0 {name=l404 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 4700 -3250 2 0 {name=l405 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 4700 -3230 2 0 {name=l406 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 4700 -3210 2 0 {name=l407 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 4700 -3190 2 0 {name=l408 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 4700 -3170 2 0 {name=l409 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 4700 -3150 2 0 {name=l410 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 4700 -3130 2 0 {name=l411 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 4700 -3110 2 0 {name=l412 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 4700 -3090 2 0 {name=l413 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 4700 -3070 2 0 {name=l414 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 4700 -3050 2 0 {name=l415 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 4700 -3030 2 0 {name=l416 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 4700 -3010 2 0 {name=l417 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 4700 -2990 2 0 {name=l418 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 4700 -2970 2 0 {name=l419 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 5240 -3590 2 0 {name=l459 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 5240 -3570 2 0 {name=l460 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 5240 -3550 2 0 {name=l461 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 5240 -3530 2 0 {name=l462 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 5240 -3510 2 0 {name=l463 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 5240 -3490 2 0 {name=l464 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 5240 -3470 2 0 {name=l465 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 5240 -3450 2 0 {name=l466 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 5240 -3430 2 0 {name=l467 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 5240 -3410 2 0 {name=l468 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 5240 -3390 2 0 {name=l469 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 5240 -3370 2 0 {name=l470 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 5240 -3350 2 0 {name=l471 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 5240 -3330 2 0 {name=l472 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 5240 -3310 2 0 {name=l473 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 5240 -3290 2 0 {name=l474 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 5240 -3270 2 0 {name=l475 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 5240 -3250 2 0 {name=l476 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 5240 -3230 2 0 {name=l477 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 5240 -3210 2 0 {name=l478 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 5240 -3190 2 0 {name=l479 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 5240 -3170 2 0 {name=l480 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 5240 -3150 2 0 {name=l481 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 5240 -3130 2 0 {name=l482 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 5240 -3110 2 0 {name=l483 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 5240 -3090 2 0 {name=l484 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 5240 -3070 2 0 {name=l485 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 5240 -3050 2 0 {name=l486 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 5240 -3030 2 0 {name=l487 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 5240 -3010 2 0 {name=l488 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 5240 -2990 2 0 {name=l489 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 5240 -2970 2 0 {name=l490 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 5760 -3590 2 0 {name=l530 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 5760 -3570 2 0 {name=l531 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 5760 -3550 2 0 {name=l532 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 5760 -3530 2 0 {name=l533 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 5760 -3510 2 0 {name=l534 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 5760 -3490 2 0 {name=l535 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 5760 -3470 2 0 {name=l536 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 5760 -3450 2 0 {name=l537 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 5760 -3430 2 0 {name=l538 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 5760 -3410 2 0 {name=l539 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 5760 -3390 2 0 {name=l540 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 5760 -3370 2 0 {name=l541 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 5760 -3350 2 0 {name=l542 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 5760 -3330 2 0 {name=l543 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 5760 -3310 2 0 {name=l544 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 5760 -3290 2 0 {name=l545 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 5760 -3270 2 0 {name=l546 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 5760 -3250 2 0 {name=l547 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 5760 -3230 2 0 {name=l548 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 5760 -3210 2 0 {name=l549 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 5760 -3190 2 0 {name=l550 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 5760 -3170 2 0 {name=l551 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 5760 -3150 2 0 {name=l552 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 5760 -3130 2 0 {name=l553 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 5760 -3110 2 0 {name=l554 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 5760 -3090 2 0 {name=l555 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 5760 -3070 2 0 {name=l556 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 5760 -3050 2 0 {name=l557 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 5760 -3030 2 0 {name=l558 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 5760 -3010 2 0 {name=l559 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 5760 -2990 2 0 {name=l560 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 5760 -2970 2 0 {name=l561 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 2080 -2690 2 0 {name=l601 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 2080 -2670 2 0 {name=l602 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 2080 -2650 2 0 {name=l603 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 2080 -2630 2 0 {name=l604 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 2080 -2610 2 0 {name=l605 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 2080 -2590 2 0 {name=l606 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 2080 -2570 2 0 {name=l607 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 2080 -2550 2 0 {name=l608 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 2080 -2530 2 0 {name=l609 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 2080 -2510 2 0 {name=l610 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 2080 -2490 2 0 {name=l611 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 2080 -2470 2 0 {name=l612 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 2080 -2450 2 0 {name=l613 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 2080 -2430 2 0 {name=l614 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 2080 -2410 2 0 {name=l615 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 2080 -2390 2 0 {name=l616 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 2080 -2370 2 0 {name=l617 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 2080 -2350 2 0 {name=l618 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 2080 -2330 2 0 {name=l619 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 2080 -2310 2 0 {name=l620 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 2080 -2290 2 0 {name=l621 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 2080 -2270 2 0 {name=l622 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 2080 -2250 2 0 {name=l623 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 2080 -2230 2 0 {name=l624 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 2080 -2210 2 0 {name=l625 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 2080 -2190 2 0 {name=l626 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 2080 -2170 2 0 {name=l627 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 2080 -2150 2 0 {name=l628 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 2080 -2130 2 0 {name=l629 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 2080 -2110 2 0 {name=l630 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 2080 -2090 2 0 {name=l631 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 2080 -2070 2 0 {name=l632 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 2090 -1740 2 0 {name=l1169 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 2090 -1720 2 0 {name=l1170 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 2090 -1700 2 0 {name=l1171 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 2090 -1680 2 0 {name=l1172 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 2090 -1660 2 0 {name=l1173 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 2090 -1640 2 0 {name=l1174 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 2090 -1620 2 0 {name=l1175 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 2090 -1600 2 0 {name=l1176 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 2090 -1580 2 0 {name=l1177 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 2090 -1560 2 0 {name=l1178 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 2090 -1540 2 0 {name=l1179 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 2090 -1520 2 0 {name=l1180 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 2090 -1500 2 0 {name=l1181 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 2090 -1480 2 0 {name=l1182 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 2090 -1460 2 0 {name=l1183 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 2090 -1440 2 0 {name=l1184 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 2090 -1420 2 0 {name=l1185 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 2090 -1400 2 0 {name=l1186 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 2090 -1380 2 0 {name=l1187 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 2090 -1360 2 0 {name=l1188 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 2090 -1340 2 0 {name=l1189 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 2090 -1320 2 0 {name=l1190 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 2090 -1300 2 0 {name=l1191 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 2090 -1280 2 0 {name=l1192 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 2090 -1260 2 0 {name=l1193 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 2090 -1240 2 0 {name=l1194 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 2090 -1220 2 0 {name=l1195 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 2090 -1200 2 0 {name=l1196 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 2090 -1180 2 0 {name=l1197 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 2090 -1160 2 0 {name=l1198 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 2090 -1140 2 0 {name=l1199 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 2090 -1120 2 0 {name=l1200 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 2090 -840 2 0 {name=l1737 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 2090 -820 2 0 {name=l1738 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 2090 -800 2 0 {name=l1739 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 2090 -780 2 0 {name=l1740 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 2090 -760 2 0 {name=l1741 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 2090 -740 2 0 {name=l1742 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 2090 -720 2 0 {name=l1743 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 2090 -700 2 0 {name=l1744 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 2090 -680 2 0 {name=l1745 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 2090 -660 2 0 {name=l1746 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 2090 -640 2 0 {name=l1747 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 2090 -620 2 0 {name=l1748 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 2090 -600 2 0 {name=l1749 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 2090 -580 2 0 {name=l1750 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 2090 -560 2 0 {name=l1751 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 2090 -540 2 0 {name=l1752 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 2090 -520 2 0 {name=l1753 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 2090 -500 2 0 {name=l1754 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 2090 -480 2 0 {name=l1755 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 2090 -460 2 0 {name=l1756 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 2090 -440 2 0 {name=l1757 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 2090 -420 2 0 {name=l1758 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 2090 -400 2 0 {name=l1759 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 2090 -380 2 0 {name=l1760 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 2090 -360 2 0 {name=l1761 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 2090 -340 2 0 {name=l1762 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 2090 -320 2 0 {name=l1763 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 2090 -300 2 0 {name=l1764 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 2090 -280 2 0 {name=l1765 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 2090 -260 2 0 {name=l1766 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 2090 -240 2 0 {name=l1767 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 2090 -220 2 0 {name=l1768 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 2600 -2690 2 0 {name=l672 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 2600 -2670 2 0 {name=l673 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 2600 -2650 2 0 {name=l674 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 2600 -2630 2 0 {name=l675 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 2600 -2610 2 0 {name=l676 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 2600 -2590 2 0 {name=l677 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 2600 -2570 2 0 {name=l678 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 2600 -2550 2 0 {name=l679 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 2600 -2530 2 0 {name=l680 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 2600 -2510 2 0 {name=l681 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 2600 -2490 2 0 {name=l682 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 2600 -2470 2 0 {name=l683 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 2600 -2450 2 0 {name=l684 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 2600 -2430 2 0 {name=l685 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 2600 -2410 2 0 {name=l686 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 2600 -2390 2 0 {name=l687 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 2600 -2370 2 0 {name=l688 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 2600 -2350 2 0 {name=l689 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 2600 -2330 2 0 {name=l690 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 2600 -2310 2 0 {name=l691 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 2600 -2290 2 0 {name=l692 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 2600 -2270 2 0 {name=l693 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 2600 -2250 2 0 {name=l694 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 2600 -2230 2 0 {name=l695 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 2600 -2210 2 0 {name=l696 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 2600 -2190 2 0 {name=l697 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 2600 -2170 2 0 {name=l698 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 2600 -2150 2 0 {name=l699 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 2600 -2130 2 0 {name=l700 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 2600 -2110 2 0 {name=l701 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 2600 -2090 2 0 {name=l702 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 2600 -2070 2 0 {name=l703 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 2610 -1740 2 0 {name=l1240 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 2610 -1720 2 0 {name=l1241 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 2610 -1700 2 0 {name=l1242 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 2610 -1680 2 0 {name=l1243 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 2610 -1660 2 0 {name=l1244 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 2610 -1640 2 0 {name=l1245 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 2610 -1620 2 0 {name=l1246 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 2610 -1600 2 0 {name=l1247 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 2610 -1580 2 0 {name=l1248 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 2610 -1560 2 0 {name=l1249 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 2610 -1540 2 0 {name=l1250 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 2610 -1520 2 0 {name=l1251 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 2610 -1500 2 0 {name=l1252 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 2610 -1480 2 0 {name=l1253 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 2610 -1460 2 0 {name=l1254 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 2610 -1440 2 0 {name=l1255 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 2610 -1420 2 0 {name=l1256 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 2610 -1400 2 0 {name=l1257 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 2610 -1380 2 0 {name=l1258 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 2610 -1360 2 0 {name=l1259 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 2610 -1340 2 0 {name=l1260 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 2610 -1320 2 0 {name=l1261 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 2610 -1300 2 0 {name=l1262 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 2610 -1280 2 0 {name=l1263 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 2610 -1260 2 0 {name=l1264 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 2610 -1240 2 0 {name=l1265 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 2610 -1220 2 0 {name=l1266 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 2610 -1200 2 0 {name=l1267 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 2610 -1180 2 0 {name=l1268 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 2610 -1160 2 0 {name=l1269 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 2610 -1140 2 0 {name=l1270 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 2610 -1120 2 0 {name=l1271 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 2610 -840 2 0 {name=l1808 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 2610 -820 2 0 {name=l1809 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 2610 -800 2 0 {name=l1810 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 2610 -780 2 0 {name=l1811 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 2610 -760 2 0 {name=l1812 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 2610 -740 2 0 {name=l1813 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 2610 -720 2 0 {name=l1814 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 2610 -700 2 0 {name=l1815 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 2610 -680 2 0 {name=l1816 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 2610 -660 2 0 {name=l1817 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 2610 -640 2 0 {name=l1818 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 2610 -620 2 0 {name=l1819 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 2610 -600 2 0 {name=l1820 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 2610 -580 2 0 {name=l1821 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 2610 -560 2 0 {name=l1822 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 2610 -540 2 0 {name=l1823 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 2610 -520 2 0 {name=l1824 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 2610 -500 2 0 {name=l1825 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 2610 -480 2 0 {name=l1826 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 2610 -460 2 0 {name=l1827 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 2610 -440 2 0 {name=l1828 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 2610 -420 2 0 {name=l1829 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 2610 -400 2 0 {name=l1830 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 2610 -380 2 0 {name=l1831 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 2610 -360 2 0 {name=l1832 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 2610 -340 2 0 {name=l1833 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 2610 -320 2 0 {name=l1834 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 2610 -300 2 0 {name=l1835 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 2610 -280 2 0 {name=l1836 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 2610 -260 2 0 {name=l1837 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 2610 -240 2 0 {name=l1838 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 2610 -220 2 0 {name=l1839 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 3140 -2690 2 0 {name=l743 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 3140 -2670 2 0 {name=l744 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 3140 -2650 2 0 {name=l745 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 3140 -2630 2 0 {name=l746 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 3140 -2610 2 0 {name=l747 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 3140 -2590 2 0 {name=l748 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 3140 -2570 2 0 {name=l749 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 3140 -2550 2 0 {name=l750 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 3140 -2530 2 0 {name=l751 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 3140 -2510 2 0 {name=l752 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 3140 -2490 2 0 {name=l753 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 3140 -2470 2 0 {name=l754 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 3140 -2450 2 0 {name=l755 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 3140 -2430 2 0 {name=l756 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 3140 -2410 2 0 {name=l757 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 3140 -2390 2 0 {name=l758 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 3140 -2370 2 0 {name=l759 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 3140 -2350 2 0 {name=l760 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 3140 -2330 2 0 {name=l761 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 3140 -2310 2 0 {name=l762 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 3140 -2290 2 0 {name=l763 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 3140 -2270 2 0 {name=l764 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 3140 -2250 2 0 {name=l765 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 3140 -2230 2 0 {name=l766 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 3140 -2210 2 0 {name=l767 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 3140 -2190 2 0 {name=l768 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 3140 -2170 2 0 {name=l769 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 3140 -2150 2 0 {name=l770 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 3140 -2130 2 0 {name=l771 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 3140 -2110 2 0 {name=l772 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 3140 -2090 2 0 {name=l773 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 3140 -2070 2 0 {name=l774 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 3150 -1740 2 0 {name=l1311 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 3150 -1720 2 0 {name=l1312 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 3150 -1700 2 0 {name=l1313 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 3150 -1680 2 0 {name=l1314 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 3150 -1660 2 0 {name=l1315 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 3150 -1640 2 0 {name=l1316 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 3150 -1620 2 0 {name=l1317 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 3150 -1600 2 0 {name=l1318 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 3150 -1580 2 0 {name=l1319 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 3150 -1560 2 0 {name=l1320 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 3150 -1540 2 0 {name=l1321 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 3150 -1520 2 0 {name=l1322 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 3150 -1500 2 0 {name=l1323 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 3150 -1480 2 0 {name=l1324 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 3150 -1460 2 0 {name=l1325 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 3150 -1440 2 0 {name=l1326 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 3150 -1420 2 0 {name=l1327 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 3150 -1400 2 0 {name=l1328 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 3150 -1380 2 0 {name=l1329 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 3150 -1360 2 0 {name=l1330 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 3150 -1340 2 0 {name=l1331 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 3150 -1320 2 0 {name=l1332 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 3150 -1300 2 0 {name=l1333 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 3150 -1280 2 0 {name=l1334 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 3150 -1260 2 0 {name=l1335 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 3150 -1240 2 0 {name=l1336 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 3150 -1220 2 0 {name=l1337 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 3150 -1200 2 0 {name=l1338 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 3150 -1180 2 0 {name=l1339 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 3150 -1160 2 0 {name=l1340 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 3150 -1140 2 0 {name=l1341 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 3150 -1120 2 0 {name=l1342 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 3150 -840 2 0 {name=l1879 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 3150 -820 2 0 {name=l1880 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 3150 -800 2 0 {name=l1881 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 3150 -780 2 0 {name=l1882 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 3150 -760 2 0 {name=l1883 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 3150 -740 2 0 {name=l1884 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 3150 -720 2 0 {name=l1885 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 3150 -700 2 0 {name=l1886 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 3150 -680 2 0 {name=l1887 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 3150 -660 2 0 {name=l1888 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 3150 -640 2 0 {name=l1889 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 3150 -620 2 0 {name=l1890 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 3150 -600 2 0 {name=l1891 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 3150 -580 2 0 {name=l1892 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 3150 -560 2 0 {name=l1893 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 3150 -540 2 0 {name=l1894 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 3150 -520 2 0 {name=l1895 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 3150 -500 2 0 {name=l1896 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 3150 -480 2 0 {name=l1897 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 3150 -460 2 0 {name=l1898 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 3150 -440 2 0 {name=l1899 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 3150 -420 2 0 {name=l1900 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 3150 -400 2 0 {name=l1901 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 3150 -380 2 0 {name=l1902 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 3150 -360 2 0 {name=l1903 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 3150 -340 2 0 {name=l1904 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 3150 -320 2 0 {name=l1905 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 3150 -300 2 0 {name=l1906 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 3150 -280 2 0 {name=l1907 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 3150 -260 2 0 {name=l1908 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 3150 -240 2 0 {name=l1909 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 3150 -220 2 0 {name=l1910 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 3660 -2690 2 0 {name=l814 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 3660 -2670 2 0 {name=l815 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 3660 -2650 2 0 {name=l816 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 3660 -2630 2 0 {name=l817 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 3660 -2610 2 0 {name=l818 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 3660 -2590 2 0 {name=l819 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 3660 -2570 2 0 {name=l820 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 3660 -2550 2 0 {name=l821 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 3660 -2530 2 0 {name=l822 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 3660 -2510 2 0 {name=l823 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 3660 -2490 2 0 {name=l824 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 3660 -2470 2 0 {name=l825 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 3660 -2450 2 0 {name=l826 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 3660 -2430 2 0 {name=l827 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 3660 -2410 2 0 {name=l828 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 3660 -2390 2 0 {name=l829 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 3660 -2370 2 0 {name=l830 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 3660 -2350 2 0 {name=l831 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 3660 -2330 2 0 {name=l832 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 3660 -2310 2 0 {name=l833 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 3660 -2290 2 0 {name=l834 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 3660 -2270 2 0 {name=l835 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 3660 -2250 2 0 {name=l836 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 3660 -2230 2 0 {name=l837 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 3660 -2210 2 0 {name=l838 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 3660 -2190 2 0 {name=l839 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 3660 -2170 2 0 {name=l840 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 3660 -2150 2 0 {name=l841 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 3660 -2130 2 0 {name=l842 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 3660 -2110 2 0 {name=l843 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 3660 -2090 2 0 {name=l844 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 3660 -2070 2 0 {name=l845 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 3670 -1740 2 0 {name=l1382 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 3670 -1720 2 0 {name=l1383 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 3670 -1700 2 0 {name=l1384 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 3670 -1680 2 0 {name=l1385 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 3670 -1660 2 0 {name=l1386 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 3670 -1640 2 0 {name=l1387 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 3670 -1620 2 0 {name=l1388 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 3670 -1600 2 0 {name=l1389 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 3670 -1580 2 0 {name=l1390 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 3670 -1560 2 0 {name=l1391 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 3670 -1540 2 0 {name=l1392 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 3670 -1520 2 0 {name=l1393 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 3670 -1500 2 0 {name=l1394 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 3670 -1480 2 0 {name=l1395 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 3670 -1460 2 0 {name=l1396 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 3670 -1440 2 0 {name=l1397 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 3670 -1420 2 0 {name=l1398 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 3670 -1400 2 0 {name=l1399 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 3670 -1380 2 0 {name=l1400 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 3670 -1360 2 0 {name=l1401 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 3670 -1340 2 0 {name=l1402 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 3670 -1320 2 0 {name=l1403 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 3670 -1300 2 0 {name=l1404 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 3670 -1280 2 0 {name=l1405 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 3670 -1260 2 0 {name=l1406 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 3670 -1240 2 0 {name=l1407 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 3670 -1220 2 0 {name=l1408 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 3670 -1200 2 0 {name=l1409 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 3670 -1180 2 0 {name=l1410 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 3670 -1160 2 0 {name=l1411 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 3670 -1140 2 0 {name=l1412 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 3670 -1120 2 0 {name=l1413 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 3670 -840 2 0 {name=l1950 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 3670 -820 2 0 {name=l1951 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 3670 -800 2 0 {name=l1952 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 3670 -780 2 0 {name=l1953 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 3670 -760 2 0 {name=l1954 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 3670 -740 2 0 {name=l1955 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 3670 -720 2 0 {name=l1956 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 3670 -700 2 0 {name=l1957 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 3670 -680 2 0 {name=l1958 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 3670 -660 2 0 {name=l1959 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 3670 -640 2 0 {name=l1960 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 3670 -620 2 0 {name=l1961 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 3670 -600 2 0 {name=l1962 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 3670 -580 2 0 {name=l1963 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 3670 -560 2 0 {name=l1964 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 3670 -540 2 0 {name=l1965 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 3670 -520 2 0 {name=l1966 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 3670 -500 2 0 {name=l1967 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 3670 -480 2 0 {name=l1968 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 3670 -460 2 0 {name=l1969 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 3670 -440 2 0 {name=l1970 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 3670 -420 2 0 {name=l1971 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 3670 -400 2 0 {name=l1972 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 3670 -380 2 0 {name=l1973 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 3670 -360 2 0 {name=l1974 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 3670 -340 2 0 {name=l1975 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 3670 -320 2 0 {name=l1976 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 3670 -300 2 0 {name=l1977 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 3670 -280 2 0 {name=l1978 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 3670 -260 2 0 {name=l1979 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 3670 -240 2 0 {name=l1980 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 3670 -220 2 0 {name=l1981 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 4180 -2690 2 0 {name=l885 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 4180 -2670 2 0 {name=l886 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 4180 -2650 2 0 {name=l887 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 4180 -2630 2 0 {name=l888 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 4180 -2610 2 0 {name=l889 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 4180 -2590 2 0 {name=l890 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 4180 -2570 2 0 {name=l891 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 4180 -2550 2 0 {name=l892 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 4180 -2530 2 0 {name=l893 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 4180 -2510 2 0 {name=l894 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 4180 -2490 2 0 {name=l895 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 4180 -2470 2 0 {name=l896 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 4180 -2450 2 0 {name=l897 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 4180 -2430 2 0 {name=l898 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 4180 -2410 2 0 {name=l899 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 4180 -2390 2 0 {name=l900 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 4180 -2370 2 0 {name=l901 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 4180 -2350 2 0 {name=l902 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 4180 -2330 2 0 {name=l903 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 4180 -2310 2 0 {name=l904 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 4180 -2290 2 0 {name=l905 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 4180 -2270 2 0 {name=l906 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 4180 -2250 2 0 {name=l907 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 4180 -2230 2 0 {name=l908 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 4180 -2210 2 0 {name=l909 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 4180 -2190 2 0 {name=l910 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 4180 -2170 2 0 {name=l911 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 4180 -2150 2 0 {name=l912 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 4180 -2130 2 0 {name=l913 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 4180 -2110 2 0 {name=l914 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 4180 -2090 2 0 {name=l915 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 4180 -2070 2 0 {name=l916 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 4190 -1740 2 0 {name=l1453 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 4190 -1720 2 0 {name=l1454 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 4190 -1700 2 0 {name=l1455 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 4190 -1680 2 0 {name=l1456 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 4190 -1660 2 0 {name=l1457 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 4190 -1640 2 0 {name=l1458 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 4190 -1620 2 0 {name=l1459 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 4190 -1600 2 0 {name=l1460 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 4190 -1580 2 0 {name=l1461 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 4190 -1560 2 0 {name=l1462 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 4190 -1540 2 0 {name=l1463 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 4190 -1520 2 0 {name=l1464 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 4190 -1500 2 0 {name=l1465 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 4190 -1480 2 0 {name=l1466 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 4190 -1460 2 0 {name=l1467 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 4190 -1440 2 0 {name=l1468 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 4190 -1420 2 0 {name=l1469 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 4190 -1400 2 0 {name=l1470 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 4190 -1380 2 0 {name=l1471 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 4190 -1360 2 0 {name=l1472 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 4190 -1340 2 0 {name=l1473 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 4190 -1320 2 0 {name=l1474 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 4190 -1300 2 0 {name=l1475 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 4190 -1280 2 0 {name=l1476 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 4190 -1260 2 0 {name=l1477 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 4190 -1240 2 0 {name=l1478 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 4190 -1220 2 0 {name=l1479 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 4190 -1200 2 0 {name=l1480 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 4190 -1180 2 0 {name=l1481 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 4190 -1160 2 0 {name=l1482 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 4190 -1140 2 0 {name=l1483 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 4190 -1120 2 0 {name=l1484 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 4190 -840 2 0 {name=l2021 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 4190 -820 2 0 {name=l2022 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 4190 -800 2 0 {name=l2023 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 4190 -780 2 0 {name=l2024 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 4190 -760 2 0 {name=l2025 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 4190 -740 2 0 {name=l2026 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 4190 -720 2 0 {name=l2027 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 4190 -700 2 0 {name=l2028 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 4190 -680 2 0 {name=l2029 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 4190 -660 2 0 {name=l2030 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 4190 -640 2 0 {name=l2031 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 4190 -620 2 0 {name=l2032 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 4190 -600 2 0 {name=l2033 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 4190 -580 2 0 {name=l2034 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 4190 -560 2 0 {name=l2035 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 4190 -540 2 0 {name=l2036 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 4190 -520 2 0 {name=l2037 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 4190 -500 2 0 {name=l2038 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 4190 -480 2 0 {name=l2039 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 4190 -460 2 0 {name=l2040 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 4190 -440 2 0 {name=l2041 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 4190 -420 2 0 {name=l2042 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 4190 -400 2 0 {name=l2043 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 4190 -380 2 0 {name=l2044 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 4190 -360 2 0 {name=l2045 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 4190 -340 2 0 {name=l2046 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 4190 -320 2 0 {name=l2047 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 4190 -300 2 0 {name=l2048 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 4190 -280 2 0 {name=l2049 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 4190 -260 2 0 {name=l2050 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 4190 -240 2 0 {name=l2051 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 4190 -220 2 0 {name=l2052 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 4700 -2690 2 0 {name=l956 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 4700 -2670 2 0 {name=l957 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 4700 -2650 2 0 {name=l958 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 4700 -2630 2 0 {name=l959 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 4700 -2610 2 0 {name=l960 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 4700 -2590 2 0 {name=l961 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 4700 -2570 2 0 {name=l962 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 4700 -2550 2 0 {name=l963 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 4700 -2530 2 0 {name=l964 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 4700 -2510 2 0 {name=l965 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 4700 -2490 2 0 {name=l966 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 4700 -2470 2 0 {name=l967 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 4700 -2450 2 0 {name=l968 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 4700 -2430 2 0 {name=l969 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 4700 -2410 2 0 {name=l970 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 4700 -2390 2 0 {name=l971 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 4700 -2370 2 0 {name=l972 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 4700 -2350 2 0 {name=l973 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 4700 -2330 2 0 {name=l974 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 4700 -2310 2 0 {name=l975 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 4700 -2290 2 0 {name=l976 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 4700 -2270 2 0 {name=l977 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 4700 -2250 2 0 {name=l978 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 4700 -2230 2 0 {name=l979 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 4700 -2210 2 0 {name=l980 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 4700 -2190 2 0 {name=l981 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 4700 -2170 2 0 {name=l982 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 4700 -2150 2 0 {name=l983 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 4700 -2130 2 0 {name=l984 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 4700 -2110 2 0 {name=l985 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 4700 -2090 2 0 {name=l986 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 4700 -2070 2 0 {name=l987 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 4710 -1740 2 0 {name=l1524 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 4710 -1720 2 0 {name=l1525 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 4710 -1700 2 0 {name=l1526 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 4710 -1680 2 0 {name=l1527 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 4710 -1660 2 0 {name=l1528 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 4710 -1640 2 0 {name=l1529 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 4710 -1620 2 0 {name=l1530 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 4710 -1600 2 0 {name=l1531 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 4710 -1580 2 0 {name=l1532 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 4710 -1560 2 0 {name=l1533 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 4710 -1540 2 0 {name=l1534 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 4710 -1520 2 0 {name=l1535 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 4710 -1500 2 0 {name=l1536 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 4710 -1480 2 0 {name=l1537 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 4710 -1460 2 0 {name=l1538 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 4710 -1440 2 0 {name=l1539 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 4710 -1420 2 0 {name=l1540 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 4710 -1400 2 0 {name=l1541 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 4710 -1380 2 0 {name=l1542 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 4710 -1360 2 0 {name=l1543 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 4710 -1340 2 0 {name=l1544 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 4710 -1320 2 0 {name=l1545 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 4710 -1300 2 0 {name=l1546 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 4710 -1280 2 0 {name=l1547 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 4710 -1260 2 0 {name=l1548 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 4710 -1240 2 0 {name=l1549 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 4710 -1220 2 0 {name=l1550 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 4710 -1200 2 0 {name=l1551 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 4710 -1180 2 0 {name=l1552 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 4710 -1160 2 0 {name=l1553 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 4710 -1140 2 0 {name=l1554 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 4710 -1120 2 0 {name=l1555 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 4710 -840 2 0 {name=l2092 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 4710 -820 2 0 {name=l2093 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 4710 -800 2 0 {name=l2094 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 4710 -780 2 0 {name=l2095 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 4710 -760 2 0 {name=l2096 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 4710 -740 2 0 {name=l2097 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 4710 -720 2 0 {name=l2098 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 4710 -700 2 0 {name=l2099 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 4710 -680 2 0 {name=l2100 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 4710 -660 2 0 {name=l2101 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 4710 -640 2 0 {name=l2102 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 4710 -620 2 0 {name=l2103 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 4710 -600 2 0 {name=l2104 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 4710 -580 2 0 {name=l2105 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 4710 -560 2 0 {name=l2106 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 4710 -540 2 0 {name=l2107 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 4710 -520 2 0 {name=l2108 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 4710 -500 2 0 {name=l2109 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 4710 -480 2 0 {name=l2110 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 4710 -460 2 0 {name=l2111 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 4710 -440 2 0 {name=l2112 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 4710 -420 2 0 {name=l2113 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 4710 -400 2 0 {name=l2114 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 4710 -380 2 0 {name=l2115 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 4710 -360 2 0 {name=l2116 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 4710 -340 2 0 {name=l2117 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 4710 -320 2 0 {name=l2118 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 4710 -300 2 0 {name=l2119 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 4710 -280 2 0 {name=l2120 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 4710 -260 2 0 {name=l2121 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 4710 -240 2 0 {name=l2122 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 4710 -220 2 0 {name=l2123 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 5240 -2690 2 0 {name=l1027 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 5240 -2670 2 0 {name=l1028 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 5240 -2650 2 0 {name=l1029 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 5240 -2630 2 0 {name=l1030 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 5240 -2610 2 0 {name=l1031 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 5240 -2590 2 0 {name=l1032 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 5240 -2570 2 0 {name=l1033 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 5240 -2550 2 0 {name=l1034 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 5240 -2530 2 0 {name=l1035 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 5240 -2510 2 0 {name=l1036 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 5240 -2490 2 0 {name=l1037 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 5240 -2470 2 0 {name=l1038 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 5240 -2450 2 0 {name=l1039 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 5240 -2430 2 0 {name=l1040 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 5240 -2410 2 0 {name=l1041 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 5240 -2390 2 0 {name=l1042 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 5240 -2370 2 0 {name=l1043 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 5240 -2350 2 0 {name=l1044 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 5240 -2330 2 0 {name=l1045 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 5240 -2310 2 0 {name=l1046 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 5240 -2290 2 0 {name=l1047 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 5240 -2270 2 0 {name=l1048 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 5240 -2250 2 0 {name=l1049 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 5240 -2230 2 0 {name=l1050 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 5240 -2210 2 0 {name=l1051 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 5240 -2190 2 0 {name=l1052 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 5240 -2170 2 0 {name=l1053 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 5240 -2150 2 0 {name=l1054 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 5240 -2130 2 0 {name=l1055 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 5240 -2110 2 0 {name=l1056 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 5240 -2090 2 0 {name=l1057 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 5240 -2070 2 0 {name=l1058 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 5250 -1740 2 0 {name=l1595 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 5250 -1720 2 0 {name=l1596 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 5250 -1700 2 0 {name=l1597 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 5250 -1680 2 0 {name=l1598 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 5250 -1660 2 0 {name=l1599 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 5250 -1640 2 0 {name=l1600 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 5250 -1620 2 0 {name=l1601 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 5250 -1600 2 0 {name=l1602 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 5250 -1580 2 0 {name=l1603 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 5250 -1560 2 0 {name=l1604 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 5250 -1540 2 0 {name=l1605 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 5250 -1520 2 0 {name=l1606 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 5250 -1500 2 0 {name=l1607 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 5250 -1480 2 0 {name=l1608 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 5250 -1460 2 0 {name=l1609 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 5250 -1440 2 0 {name=l1610 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 5250 -1420 2 0 {name=l1611 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 5250 -1400 2 0 {name=l1612 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 5250 -1380 2 0 {name=l1613 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 5250 -1360 2 0 {name=l1614 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 5250 -1340 2 0 {name=l1615 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 5250 -1320 2 0 {name=l1616 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 5250 -1300 2 0 {name=l1617 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 5250 -1280 2 0 {name=l1618 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 5250 -1260 2 0 {name=l1619 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 5250 -1240 2 0 {name=l1620 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 5250 -1220 2 0 {name=l1621 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 5250 -1200 2 0 {name=l1622 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 5250 -1180 2 0 {name=l1623 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 5250 -1160 2 0 {name=l1624 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 5250 -1140 2 0 {name=l1625 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 5250 -1120 2 0 {name=l1626 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 5250 -840 2 0 {name=l2163 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 5250 -820 2 0 {name=l2164 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 5250 -800 2 0 {name=l2165 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 5250 -780 2 0 {name=l2166 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 5250 -760 2 0 {name=l2167 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 5250 -740 2 0 {name=l2168 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 5250 -720 2 0 {name=l2169 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 5250 -700 2 0 {name=l2170 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 5250 -680 2 0 {name=l2171 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 5250 -660 2 0 {name=l2172 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 5250 -640 2 0 {name=l2173 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 5250 -620 2 0 {name=l2174 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 5250 -600 2 0 {name=l2175 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 5250 -580 2 0 {name=l2176 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 5250 -560 2 0 {name=l2177 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 5250 -540 2 0 {name=l2178 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 5250 -520 2 0 {name=l2179 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 5250 -500 2 0 {name=l2180 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 5250 -480 2 0 {name=l2181 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 5250 -460 2 0 {name=l2182 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 5250 -440 2 0 {name=l2183 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 5250 -420 2 0 {name=l2184 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 5250 -400 2 0 {name=l2185 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 5250 -380 2 0 {name=l2186 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 5250 -360 2 0 {name=l2187 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 5250 -340 2 0 {name=l2188 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 5250 -320 2 0 {name=l2189 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 5250 -300 2 0 {name=l2190 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 5250 -280 2 0 {name=l2191 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 5250 -260 2 0 {name=l2192 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 5250 -240 2 0 {name=l2193 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 5250 -220 2 0 {name=l2194 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 5760 -2690 2 0 {name=l1098 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 5760 -2670 2 0 {name=l1099 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 5760 -2650 2 0 {name=l1100 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 5760 -2630 2 0 {name=l1101 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 5760 -2610 2 0 {name=l1102 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 5760 -2590 2 0 {name=l1103 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 5760 -2570 2 0 {name=l1104 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 5760 -2550 2 0 {name=l1105 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 5760 -2530 2 0 {name=l1106 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 5760 -2510 2 0 {name=l1107 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 5760 -2490 2 0 {name=l1108 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 5760 -2470 2 0 {name=l1109 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 5760 -2450 2 0 {name=l1110 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 5760 -2430 2 0 {name=l1111 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 5760 -2410 2 0 {name=l1112 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 5760 -2390 2 0 {name=l1113 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 5760 -2370 2 0 {name=l1114 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 5760 -2350 2 0 {name=l1115 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 5760 -2330 2 0 {name=l1116 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 5760 -2310 2 0 {name=l1117 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 5760 -2290 2 0 {name=l1118 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 5760 -2270 2 0 {name=l1119 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 5760 -2250 2 0 {name=l1120 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 5760 -2230 2 0 {name=l1121 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 5760 -2210 2 0 {name=l1122 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 5760 -2190 2 0 {name=l1123 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 5760 -2170 2 0 {name=l1124 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 5760 -2150 2 0 {name=l1125 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 5760 -2130 2 0 {name=l1126 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 5760 -2110 2 0 {name=l1127 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 5760 -2090 2 0 {name=l1128 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 5760 -2070 2 0 {name=l1129 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 5770 -1740 2 0 {name=l1666 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 5770 -1720 2 0 {name=l1667 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 5770 -1700 2 0 {name=l1668 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 5770 -1680 2 0 {name=l1669 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 5770 -1660 2 0 {name=l1670 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 5770 -1640 2 0 {name=l1671 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 5770 -1620 2 0 {name=l1672 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 5770 -1600 2 0 {name=l1673 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 5770 -1580 2 0 {name=l1674 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 5770 -1560 2 0 {name=l1675 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 5770 -1540 2 0 {name=l1676 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 5770 -1520 2 0 {name=l1677 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 5770 -1500 2 0 {name=l1678 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 5770 -1480 2 0 {name=l1679 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 5770 -1460 2 0 {name=l1680 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 5770 -1440 2 0 {name=l1681 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 5770 -1420 2 0 {name=l1682 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 5770 -1400 2 0 {name=l1683 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 5770 -1380 2 0 {name=l1684 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 5770 -1360 2 0 {name=l1685 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 5770 -1340 2 0 {name=l1686 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 5770 -1320 2 0 {name=l1687 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 5770 -1300 2 0 {name=l1688 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 5770 -1280 2 0 {name=l1689 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 5770 -1260 2 0 {name=l1690 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 5770 -1240 2 0 {name=l1691 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 5770 -1220 2 0 {name=l1692 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 5770 -1200 2 0 {name=l1693 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 5770 -1180 2 0 {name=l1694 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 5770 -1160 2 0 {name=l1695 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 5770 -1140 2 0 {name=l1696 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 5770 -1120 2 0 {name=l1697 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 5770 -840 2 0 {name=l2234 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 5770 -820 2 0 {name=l2235 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 5770 -800 2 0 {name=l2236 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 5770 -780 2 0 {name=l2237 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 5770 -760 2 0 {name=l2238 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 5770 -740 2 0 {name=l2239 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 5770 -720 2 0 {name=l2240 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 5770 -700 2 0 {name=l2241 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 5770 -680 2 0 {name=l2242 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 5770 -660 2 0 {name=l2243 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 5770 -640 2 0 {name=l2244 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 5770 -620 2 0 {name=l2245 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 5770 -600 2 0 {name=l2246 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 5770 -580 2 0 {name=l2247 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 5770 -560 2 0 {name=l2248 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 5770 -540 2 0 {name=l2249 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 5770 -520 2 0 {name=l2250 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 5770 -500 2 0 {name=l2251 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 5770 -480 2 0 {name=l2252 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 5770 -460 2 0 {name=l2253 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 5770 -440 2 0 {name=l2254 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 5770 -420 2 0 {name=l2255 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 5770 -400 2 0 {name=l2256 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 5770 -380 2 0 {name=l2257 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 5770 -360 2 0 {name=l2258 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 5770 -340 2 0 {name=l2259 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 5770 -320 2 0 {name=l2260 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 5770 -300 2 0 {name=l2261 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 5770 -280 2 0 {name=l2262 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 5770 -260 2 0 {name=l2263 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 5770 -240 2 0 {name=l2264 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 5770 -220 2 0 {name=l2265 sig_type=std_logic lab=Do31}
C {code_shown.sym} 10 -4390 0 0 {name=s1 only_toplevel=false value="
.control
save all
tran 25p 18n
write tb_RAM32_nf8.raw
.endc
"}
C {devices/code_shown.sym} 310 -4380 0 0 {name=MODELS only_toplevel=true
format="tcleval( @value )"
value="
.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical
"}
C {devices/launcher.sym} 65 -4545 0 0 {name=h1
descr="Click left mouse button here with control key
pressed to load/unload waveforms in graph."
tclcommand="
xschem raw_read $netlist_dir/[file tail [file rootname [xschem get current_name]]].raw
"
}
