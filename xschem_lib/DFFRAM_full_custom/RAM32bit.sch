v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
T {PINS} 70 -4280 0 0 3 3 {}
T {WORD x 32} 4150 -4240 0 0 5 5 {}
T {BUF_SEL} 50 -2150 0 0 4 4 {}
T {BUF_IN} 80 -1070 0 0 4 4 {}
T {BUF_CLK} 920 -4160 0 0 2 2 {}
T {BUF_WE} 1970 -3670 0 0 2 2 {}
T {DEC2to4 x1
DEC3to8 x4} 10 -3350 0 0 3 3 {}
N 1080 -3230 1100 -3230 {
lab=A3}
N 1080 -3210 1100 -3210 {
lab=A4}
N 1080 -3190 1100 -3190 {
lab=EN}
N 1260 -3260 1270 -3260 {
lab=#net1}
N 1260 -3240 1270 -3240 {
lab=#net2}
N 1260 -3220 1270 -3220 {
lab=#net3}
N 1260 -3200 1270 -3200 {
lab=#net4}
N 1270 -3610 1270 -3260 {
lab=#net1}
N 1270 -3610 1520 -3610 {
lab=#net1}
N 1300 -3360 1520 -3360 {
lab=#net2}
N 1300 -3360 1300 -3240 {
lab=#net2}
N 1270 -3240 1300 -3240 {
lab=#net2}
N 1300 -3110 1520 -3110 {
lab=#net3}
N 1300 -3220 1300 -3110 {
lab=#net3}
N 1270 -3220 1300 -3220 {
lab=#net3}
N 1270 -3200 1270 -2850 {
lab=#net4}
N 1270 -2850 1520 -2850 {
lab=#net4}
N 1440 -3590 1520 -3590 {
lab=A2}
N 1440 -3590 1440 -2830 {
lab=A2}
N 1440 -2830 1520 -2830 {
lab=A2}
N 1440 -3090 1520 -3090 {
lab=A2}
N 1440 -3340 1520 -3340 {
lab=A2}
N 1460 -3570 1520 -3570 {
lab=A1}
N 1400 -3570 1460 -3570 {
lab=A1}
N 1400 -3570 1400 -2810 {
lab=A1}
N 1400 -2810 1520 -2810 {
lab=A1}
N 1400 -3070 1520 -3070 {
lab=A1}
N 1400 -3320 1520 -3320 {
lab=A1}
N 1360 -3550 1520 -3550 {
lab=A0}
N 1360 -3550 1360 -2790 {
lab=A0}
N 1360 -2790 1520 -2790 {
lab=A0}
N 1360 -3300 1520 -3300 {
lab=A0}
N 1360 -3050 1520 -3050 {
lab=A0}
N 1080 -3090 1440 -3090 {
lab=A2}
N 1080 -3070 1400 -3070 {
lab=A1}
N 1080 -3050 1360 -3050 {
lab=A0}
N 1510 -3670 1520 -3670 {
lab=VDD}
N 1510 -3650 1520 -3650 {
lab=VSS}
N 1510 -3420 1520 -3420 {
lab=VDD}
N 1510 -3400 1520 -3400 {
lab=VSS}
N 1510 -3170 1520 -3170 {
lab=VDD}
N 1510 -3150 1520 -3150 {
lab=VSS}
N 1510 -2910 1520 -2910 {
lab=VDD}
N 1510 -2890 1520 -2890 {
lab=VSS}
N 1090 -3270 1100 -3270 {
lab=VDD}
N 1090 -3250 1100 -3250 {
lab=VSS}
N 1510 -3670 1520 -3670 {
lab=VDD}
N 1510 -3650 1520 -3650 {
lab=VSS}
N 1510 -3420 1520 -3420 {
lab=VDD}
N 1510 -3400 1520 -3400 {
lab=VSS}
N 1510 -3170 1520 -3170 {
lab=VDD}
N 1510 -3150 1520 -3150 {
lab=VSS}
N 1510 -2910 1520 -2910 {
lab=VDD}
N 1510 -2890 1520 -2890 {
lab=VSS}
N 1240 -2570 1260 -2570 {
lab=#net5}
N 1160 -2610 1320 -2610 {
lab=VDD}
N 1160 -2530 1320 -2530 {
lab=VSS}
N 1690 -3680 1710 -3680 {
lab=Y0}
N 1690 -3660 1710 -3660 {
lab=Y1}
N 1690 -3640 1710 -3640 {
lab=Y2}
N 1690 -3620 1710 -3620 {
lab=Y3}
N 1690 -3600 1710 -3600 {
lab=Y4}
N 1690 -3580 1710 -3580 {
lab=Y5}
N 1690 -3560 1710 -3560 {
lab=Y6}
N 1690 -3540 1710 -3540 {
lab=Y7}
N 1690 -3430 1710 -3430 {
lab=Y8}
N 1690 -3410 1710 -3410 {
lab=Y9}
N 1690 -3390 1710 -3390 {
lab=Y10}
N 1690 -3370 1710 -3370 {
lab=Y11}
N 1690 -3350 1710 -3350 {
lab=Y12}
N 1690 -3330 1710 -3330 {
lab=Y13}
N 1690 -3310 1710 -3310 {
lab=Y14}
N 1690 -3290 1710 -3290 {
lab=Y15}
N 1690 -3180 1710 -3180 {
lab=Y16}
N 1690 -3160 1710 -3160 {
lab=Y17}
N 1690 -3140 1710 -3140 {
lab=Y18}
N 1690 -3120 1710 -3120 {
lab=Y19}
N 1690 -3100 1710 -3100 {
lab=Y20}
N 1690 -3080 1710 -3080 {
lab=Y21}
N 1690 -3060 1710 -3060 {
lab=Y22}
N 1690 -3040 1710 -3040 {
lab=Y23}
N 1690 -2920 1710 -2920 {
lab=Y24}
N 1690 -2900 1710 -2900 {
lab=Y25}
N 1690 -2880 1710 -2880 {
lab=Y26}
N 1690 -2860 1710 -2860 {
lab=Y27}
N 1690 -2840 1710 -2840 {
lab=Y28}
N 1690 -2820 1710 -2820 {
lab=Y29}
N 1690 -2800 1710 -2800 {
lab=Y30}
N 1690 -2780 1710 -2780 {
lab=Y31}
N 1400 -2570 1420 -2570 {
lab=SEL[0]}
N 1090 -2570 1100 -2570 {
lab=Y0}
N 1600 -2570 1620 -2570 {
lab=#net6}
N 1520 -2610 1680 -2610 {
lab=VDD}
N 1520 -2530 1680 -2530 {
lab=VSS}
N 1760 -2570 1780 -2570 {
lab=SEL1}
N 1450 -2570 1460 -2570 {
lab=Y1}
N 1980 -2570 2000 -2570 {
lab=#net7}
N 1900 -2610 2060 -2610 {
lab=VDD}
N 1900 -2530 2060 -2530 {
lab=VSS}
N 2140 -2570 2160 -2570 {
lab=SEL[2]}
N 1830 -2570 1840 -2570 {
lab=Y2}
N 2340 -2570 2360 -2570 {
lab=#net8}
N 2260 -2610 2420 -2610 {
lab=VDD}
N 2260 -2530 2420 -2530 {
lab=VSS}
N 2500 -2570 2520 -2570 {
lab=SEL[3]}
N 2190 -2570 2200 -2570 {
lab=Y3}
N 1240 -2400 1260 -2400 {
lab=#net9}
N 1160 -2440 1320 -2440 {
lab=VDD}
N 1160 -2360 1320 -2360 {
lab=VSS}
N 1400 -2400 1420 -2400 {
lab=SEL[4]}
N 1090 -2400 1100 -2400 {
lab=Y4}
N 1600 -2400 1620 -2400 {
lab=#net10}
N 1520 -2440 1680 -2440 {
lab=VDD}
N 1520 -2360 1680 -2360 {
lab=VSS}
N 1760 -2400 1780 -2400 {
lab=SEL[5]}
N 1450 -2400 1460 -2400 {
lab=Y5}
N 1980 -2400 2000 -2400 {
lab=#net11}
N 1900 -2440 2060 -2440 {
lab=VDD}
N 1900 -2360 2060 -2360 {
lab=VSS}
N 2140 -2400 2160 -2400 {
lab=SEL[6]}
N 1830 -2400 1840 -2400 {
lab=Y6}
N 2340 -2400 2360 -2400 {
lab=#net12}
N 2260 -2440 2420 -2440 {
lab=VDD}
N 2260 -2360 2420 -2360 {
lab=VSS}
N 2500 -2400 2520 -2400 {
lab=SEL[7]}
N 2190 -2400 2200 -2400 {
lab=Y7}
N 1230 -2230 1250 -2230 {
lab=#net13}
N 1150 -2270 1310 -2270 {
lab=VDD}
N 1150 -2190 1310 -2190 {
lab=VSS}
N 1390 -2230 1410 -2230 {
lab=SEL[8]}
N 1080 -2230 1090 -2230 {
lab=Y8}
N 1590 -2230 1610 -2230 {
lab=#net14}
N 1510 -2270 1670 -2270 {
lab=VDD}
N 1510 -2190 1670 -2190 {
lab=VSS}
N 1750 -2230 1770 -2230 {
lab=SEL[9]}
N 1440 -2230 1450 -2230 {
lab=Y9}
N 1970 -2230 1990 -2230 {
lab=#net15}
N 1890 -2270 2050 -2270 {
lab=VDD}
N 1890 -2190 2050 -2190 {
lab=VSS}
N 2130 -2230 2150 -2230 {
lab=SEL[10]}
N 1820 -2230 1830 -2230 {
lab=Y10}
N 2330 -2230 2350 -2230 {
lab=#net16}
N 2250 -2270 2410 -2270 {
lab=VDD}
N 2250 -2190 2410 -2190 {
lab=VSS}
N 2490 -2230 2510 -2230 {
lab=SEL[11]}
N 2180 -2230 2190 -2230 {
lab=Y11}
N 1230 -2060 1250 -2060 {
lab=#net17}
N 1150 -2100 1310 -2100 {
lab=VDD}
N 1150 -2020 1310 -2020 {
lab=VSS}
N 1390 -2060 1410 -2060 {
lab=SEL[12]}
N 1080 -2060 1090 -2060 {
lab=Y12}
N 1590 -2060 1610 -2060 {
lab=#net18}
N 1510 -2100 1670 -2100 {
lab=VDD}
N 1510 -2020 1670 -2020 {
lab=VSS}
N 1750 -2060 1770 -2060 {
lab=SEL[13]}
N 1440 -2060 1450 -2060 {
lab=Y13}
N 1970 -2060 1990 -2060 {
lab=#net19}
N 1890 -2100 2050 -2100 {
lab=VDD}
N 1890 -2020 2050 -2020 {
lab=VSS}
N 2130 -2060 2150 -2060 {
lab=SEL[14]}
N 1820 -2060 1830 -2060 {
lab=Y14}
N 2330 -2060 2350 -2060 {
lab=#net20}
N 2250 -2100 2410 -2100 {
lab=VDD}
N 2250 -2020 2410 -2020 {
lab=VSS}
N 2490 -2060 2510 -2060 {
lab=SEL[15]}
N 2180 -2060 2190 -2060 {
lab=Y15}
N 1240 -1890 1260 -1890 {
lab=#net21}
N 1160 -1930 1320 -1930 {
lab=VDD}
N 1160 -1850 1320 -1850 {
lab=VSS}
N 1400 -1890 1420 -1890 {
lab=SEL[16]}
N 1090 -1890 1100 -1890 {
lab=Y16}
N 1600 -1890 1620 -1890 {
lab=#net22}
N 1520 -1930 1680 -1930 {
lab=VDD}
N 1520 -1850 1680 -1850 {
lab=VSS}
N 1760 -1890 1780 -1890 {
lab=SEL[17]}
N 1450 -1890 1460 -1890 {
lab=Y17}
N 1980 -1890 2000 -1890 {
lab=#net23}
N 1900 -1930 2060 -1930 {
lab=VDD}
N 1900 -1850 2060 -1850 {
lab=VSS}
N 2140 -1890 2160 -1890 {
lab=SEL[18]}
N 1830 -1890 1840 -1890 {
lab=Y18}
N 2340 -1890 2360 -1890 {
lab=#net24}
N 2260 -1930 2420 -1930 {
lab=VDD}
N 2260 -1850 2420 -1850 {
lab=VSS}
N 2500 -1890 2520 -1890 {
lab=SEL[19]}
N 2190 -1890 2200 -1890 {
lab=Y19}
N 1240 -1720 1260 -1720 {
lab=#net25}
N 1160 -1760 1320 -1760 {
lab=VDD}
N 1160 -1680 1320 -1680 {
lab=VSS}
N 1400 -1720 1420 -1720 {
lab=SEL[20]}
N 1090 -1720 1100 -1720 {
lab=Y20}
N 1600 -1720 1620 -1720 {
lab=#net26}
N 1520 -1760 1680 -1760 {
lab=VDD}
N 1520 -1680 1680 -1680 {
lab=VSS}
N 1760 -1720 1780 -1720 {
lab=SEL[21]}
N 1450 -1720 1460 -1720 {
lab=Y21}
N 1980 -1720 2000 -1720 {
lab=#net27}
N 1900 -1760 2060 -1760 {
lab=VDD}
N 1900 -1680 2060 -1680 {
lab=VSS}
N 2140 -1720 2160 -1720 {
lab=SEL[22]}
N 1830 -1720 1840 -1720 {
lab=Y22}
N 2340 -1720 2360 -1720 {
lab=#net28}
N 2260 -1760 2420 -1760 {
lab=VDD}
N 2260 -1680 2420 -1680 {
lab=VSS}
N 2500 -1720 2520 -1720 {
lab=SEL[23]}
N 2190 -1720 2200 -1720 {
lab=Y23}
N 1240 -1550 1260 -1550 {
lab=#net29}
N 1160 -1590 1320 -1590 {
lab=VDD}
N 1160 -1510 1320 -1510 {
lab=VSS}
N 1400 -1550 1420 -1550 {
lab=SEL[24]}
N 1090 -1550 1100 -1550 {
lab=Y24}
N 1600 -1550 1620 -1550 {
lab=#net30}
N 1520 -1590 1680 -1590 {
lab=VDD}
N 1520 -1510 1680 -1510 {
lab=VSS}
N 1760 -1550 1780 -1550 {
lab=SEL[25]}
N 1450 -1550 1460 -1550 {
lab=Y25}
N 1980 -1550 2000 -1550 {
lab=#net31}
N 1900 -1590 2060 -1590 {
lab=VDD}
N 1900 -1510 2060 -1510 {
lab=VSS}
N 2140 -1550 2160 -1550 {
lab=SEL[26]}
N 1830 -1550 1840 -1550 {
lab=Y26}
N 2340 -1550 2360 -1550 {
lab=#net32}
N 2260 -1590 2420 -1590 {
lab=VDD}
N 2260 -1510 2420 -1510 {
lab=VSS}
N 2500 -1550 2520 -1550 {
lab=SEL[27]}
N 2190 -1550 2200 -1550 {
lab=Y27}
N 1240 -1380 1260 -1380 {
lab=#net33}
N 1160 -1420 1320 -1420 {
lab=VDD}
N 1160 -1340 1320 -1340 {
lab=VSS}
N 1400 -1380 1420 -1380 {
lab=SEL[28]}
N 1090 -1380 1100 -1380 {
lab=Y28}
N 1600 -1380 1620 -1380 {
lab=#net34}
N 1520 -1420 1680 -1420 {
lab=VDD}
N 1520 -1340 1680 -1340 {
lab=VSS}
N 1760 -1380 1780 -1380 {
lab=SEL[29]}
N 1450 -1380 1460 -1380 {
lab=Y29}
N 1980 -1380 2000 -1380 {
lab=#net35}
N 1900 -1420 2060 -1420 {
lab=VDD}
N 1900 -1340 2060 -1340 {
lab=VSS}
N 2140 -1380 2160 -1380 {
lab=SEL[30]}
N 1830 -1380 1840 -1380 {
lab=Y30}
N 2340 -1380 2360 -1380 {
lab=#net36}
N 2260 -1420 2420 -1420 {
lab=VDD}
N 2260 -1340 2420 -1340 {
lab=VSS}
N 2500 -1380 2520 -1380 {
lab=SEL[31]}
N 2190 -1380 2200 -1380 {
lab=Y31}
N 1230 -3920 1250 -3920 {
lab=#net37}
N 1250 -3920 1270 -3920 {
lab=#net37}
N 1080 -3920 1090 -3920 {
lab=#net38}
N 2060 -3030 2080 -3030 {
lab=#net39}
N 1980 -3070 2140 -3070 {
lab=VDD}
N 1980 -2990 2140 -2990 {
lab=VSS}
N 2220 -3030 2240 -3030 {
lab=we3_buf}
N 1910 -3030 1920 -3030 {
lab=WE3}
N 2060 -3150 2080 -3150 {
lab=#net40}
N 1980 -3190 2140 -3190 {
lab=VDD}
N 1980 -3110 2140 -3110 {
lab=VSS}
N 2220 -3150 2240 -3150 {
lab=we2_buf}
N 1910 -3150 1920 -3150 {
lab=WE2}
N 2060 -3280 2080 -3280 {
lab=#net41}
N 1980 -3320 2140 -3320 {
lab=VDD}
N 1980 -3240 2140 -3240 {
lab=VSS}
N 2220 -3280 2240 -3280 {
lab=we1_buf}
N 1910 -3280 1920 -3280 {
lab=WE1}
N 2060 -3400 2080 -3400 {
lab=#net42}
N 1980 -3440 2140 -3440 {
lab=VDD}
N 1980 -3360 2140 -3360 {
lab=VSS}
N 2220 -3400 2240 -3400 {
lab=we0_buf}
N 1910 -3400 1920 -3400 {
lab=WE0}
N 1240 -1090 1260 -1090 {
lab=#net43}
N 1160 -1130 1320 -1130 {
lab=VDD}
N 1160 -1050 1320 -1050 {
lab=VSS}
N 1400 -1090 1420 -1090 {
lab=di0_buf}
N 1070 -1090 1080 -1090 {
lab=Di0}
N 1800 -1090 1820 -1090 {
lab=di1_buf}
N 1240 -960 1260 -960 {
lab=#net44}
N 1160 -1000 1320 -1000 {
lab=VDD}
N 1160 -920 1320 -920 {
lab=VSS}
N 1400 -960 1420 -960 {
lab=di4_buf}
N 1070 -960 1080 -960 {
lab=Di4}
N 2600 -1090 2620 -1090 {
lab=di3_buf}
N 2600 -960 2620 -960 {
lab=di7_buf}
N 2200 -960 2220 -960 {
lab=di6_buf}
N 2200 -1090 2220 -1090 {
lab=di2_buf}
N 2600 -1090 2620 -1090 {
lab=di3_buf}
N 2600 -960 2620 -960 {
lab=di7_buf}
N 1800 -960 1820 -960 {
lab=di5_buf}
N 1240 -830 1260 -830 {
lab=#net45}
N 1160 -870 1320 -870 {
lab=VDD}
N 1160 -790 1320 -790 {
lab=VSS}
N 1400 -830 1420 -830 {
lab=di8_buf}
N 1070 -830 1080 -830 {
lab=Di8}
N 1800 -830 1820 -830 {
lab=di9_buf}
N 2200 -830 2220 -830 {
lab=di10_buf}
N 2600 -830 2620 -830 {
lab=di11_buf}
N 2600 -700 2620 -700 {
lab=di15_buf}
N 2200 -700 2220 -700 {
lab=di14_buf}
N 1800 -700 1820 -700 {
lab=di13_buf}
N 1240 -700 1260 -700 {
lab=#net46}
N 1160 -740 1320 -740 {
lab=VDD}
N 1160 -660 1320 -660 {
lab=VSS}
N 1400 -700 1420 -700 {
lab=di12_buf}
N 1070 -700 1080 -700 {
lab=Di12}
N 1240 -570 1260 -570 {
lab=#net47}
N 1160 -610 1320 -610 {
lab=VDD}
N 1160 -530 1320 -530 {
lab=VSS}
N 1400 -570 1420 -570 {
lab=di16_buf}
N 1070 -570 1080 -570 {
lab=Di16}
N 1240 -440 1260 -440 {
lab=#net48}
N 1160 -480 1320 -480 {
lab=VDD}
N 1160 -400 1320 -400 {
lab=VSS}
N 1400 -440 1420 -440 {
lab=Di[20]}
N 1070 -440 1080 -440 {
lab=Di20}
N 1240 -310 1260 -310 {
lab=#net49}
N 1160 -350 1320 -350 {
lab=VDD}
N 1160 -270 1320 -270 {
lab=VSS}
N 1400 -310 1420 -310 {
lab=Di[24]}
N 1070 -310 1080 -310 {
lab=Di24}
N 1240 -180 1260 -180 {
lab=#net50}
N 1160 -220 1320 -220 {
lab=VDD}
N 1160 -140 1320 -140 {
lab=VSS}
N 1400 -180 1420 -180 {
lab=Di[28]}
N 1070 -180 1080 -180 {
lab=Di28}
N 1800 -180 1820 -180 {
lab=Di[29]}
N 1800 -310 1820 -310 {
lab=Di[25]}
N 1800 -440 1820 -440 {
lab=Di[21]}
N 1800 -570 1820 -570 {
lab=Di[17]}
N 2200 -570 2220 -570 {
lab=Di[18]}
N 2200 -440 2220 -440 {
lab=Di[22]}
N 2200 -310 2220 -310 {
lab=Di[26]}
N 2200 -180 2220 -180 {
lab=Di[30]}
N 2600 -180 2620 -180 {
lab=Di[31]}
N 2600 -310 2620 -310 {
lab=Di[27]}
N 2600 -440 2620 -440 {
lab=Di[23]}
N 2600 -570 2620 -570 {
lab=Di[19]}
N 2820 -3690 2840 -3690 {
lab=di0_buf}
N 2820 -3670 2840 -3670 {
lab=di1_buf}
N 2820 -3650 2840 -3650 {
lab=di2_buf}
N 2820 -3630 2840 -3630 {
lab=di3_buf}
N 2820 -3610 2840 -3610 {
lab=di4_buf}
N 2820 -3590 2840 -3590 {
lab=di5_buf}
N 2820 -3570 2840 -3570 {
lab=di6_buf}
N 2820 -3550 2840 -3550 {
lab=di7_buf}
N 2820 -3530 2840 -3530 {
lab=di8_buf}
N 2820 -3510 2840 -3510 {
lab=di9_buf}
N 2820 -3490 2840 -3490 {
lab=di10_buf}
N 2820 -3470 2840 -3470 {
lab=di11_buf}
N 2820 -3450 2840 -3450 {
lab=di12_buf}
N 2820 -3430 2840 -3430 {
lab=di13_buf}
N 2820 -3410 2840 -3410 {
lab=di14_buf}
N 2820 -3390 2840 -3390 {
lab=di15_buf}
N 2820 -3370 2840 -3370 {
lab=di16_buf}
N 2820 -3350 2840 -3350 {
lab=Di[17]}
N 2820 -3330 2840 -3330 {
lab=Di[18]}
N 2820 -3310 2840 -3310 {
lab=Di[19]}
N 2820 -3290 2840 -3290 {
lab=Di[20]}
N 2820 -3270 2840 -3270 {
lab=Di[21]}
N 2820 -3250 2840 -3250 {
lab=Di[22]}
N 2820 -3230 2840 -3230 {
lab=Di[23]}
N 2820 -3210 2840 -3210 {
lab=Di[24]}
N 2820 -3190 2840 -3190 {
lab=Di[25]}
N 2820 -3170 2840 -3170 {
lab=Di[26]}
N 2820 -3150 2840 -3150 {
lab=Di[27]}
N 2820 -3130 2840 -3130 {
lab=Di[28]}
N 2820 -3110 2840 -3110 {
lab=Di[29]}
N 2820 -3090 2840 -3090 {
lab=Di[30]}
N 2820 -3070 2840 -3070 {
lab=Di[31]}
N 3140 -3690 3160 -3690 {
lab=Do0}
N 3140 -3670 3160 -3670 {
lab=Do1}
N 3140 -3650 3160 -3650 {
lab=Do2}
N 3140 -3630 3160 -3630 {
lab=Do3}
N 3140 -3610 3160 -3610 {
lab=Do4}
N 3140 -3590 3160 -3590 {
lab=Do5}
N 3140 -3570 3160 -3570 {
lab=Do6}
N 3140 -3550 3160 -3550 {
lab=Do7}
N 3140 -3530 3160 -3530 {
lab=Do8}
N 3140 -3510 3160 -3510 {
lab=Do9}
N 3140 -3490 3160 -3490 {
lab=Do10}
N 3140 -3470 3160 -3470 {
lab=Do11}
N 3140 -3450 3160 -3450 {
lab=Do12}
N 3140 -3430 3160 -3430 {
lab=Do13}
N 3140 -3410 3160 -3410 {
lab=Do14}
N 3140 -3390 3160 -3390 {
lab=Do15}
N 3140 -3370 3160 -3370 {
lab=Do16}
N 3140 -3350 3160 -3350 {
lab=Do17}
N 3140 -3330 3160 -3330 {
lab=Do18}
N 3140 -3310 3160 -3310 {
lab=Do19}
N 3140 -3290 3160 -3290 {
lab=Do20}
N 3140 -3270 3160 -3270 {
lab=Do21}
N 3140 -3250 3160 -3250 {
lab=Do22}
N 3140 -3230 3160 -3230 {
lab=Do23}
N 3140 -3210 3160 -3210 {
lab=Do24}
N 3140 -3190 3160 -3190 {
lab=Do25}
N 3140 -3170 3160 -3170 {
lab=Do26}
N 3140 -3150 3160 -3150 {
lab=Do27}
N 3140 -3130 3160 -3130 {
lab=Do28}
N 3140 -3110 3160 -3110 {
lab=Do29}
N 3140 -3090 3160 -3090 {
lab=Do30}
N 3140 -3070 3160 -3070 {
lab=Do31}
N 2910 -3750 2910 -3730 {
lab=CLK_buf}
N 2930 -3750 2930 -3730 {
lab=SEL[0]}
N 2950 -3750 2950 -3730 {
lab=we0_buf}
N 2970 -3750 2970 -3730 {
lab=we1_buf}
N 2990 -3750 2990 -3730 {
lab=we2_buf}
N 3010 -3750 3010 -3730 {
lab=we3_buf}
N 3040 -3750 3040 -3730 {
lab=VDD}
N 3060 -3750 3060 -3730 {
lab=VSS}
N 3340 -3690 3360 -3690 {
lab=di0_buf}
N 3340 -3670 3360 -3670 {
lab=di1_buf}
N 3340 -3650 3360 -3650 {
lab=di2_buf}
N 3340 -3630 3360 -3630 {
lab=di3_buf}
N 3340 -3610 3360 -3610 {
lab=di4_buf}
N 3340 -3590 3360 -3590 {
lab=di5_buf}
N 3340 -3570 3360 -3570 {
lab=di6_buf}
N 3340 -3550 3360 -3550 {
lab=di7_buf}
N 3340 -3530 3360 -3530 {
lab=di8_buf}
N 3340 -3510 3360 -3510 {
lab=di9_buf}
N 3340 -3490 3360 -3490 {
lab=di10_buf}
N 3340 -3470 3360 -3470 {
lab=di11_buf}
N 3340 -3450 3360 -3450 {
lab=di12_buf}
N 3340 -3430 3360 -3430 {
lab=di13_buf}
N 3340 -3410 3360 -3410 {
lab=di14_buf}
N 3340 -3390 3360 -3390 {
lab=di15_buf}
N 3340 -3370 3360 -3370 {
lab=di16_buf}
N 3340 -3350 3360 -3350 {
lab=Di[17]}
N 3340 -3330 3360 -3330 {
lab=Di[18]}
N 3340 -3310 3360 -3310 {
lab=Di[19]}
N 3340 -3290 3360 -3290 {
lab=Di[20]}
N 3340 -3270 3360 -3270 {
lab=Di[21]}
N 3340 -3250 3360 -3250 {
lab=Di[22]}
N 3340 -3230 3360 -3230 {
lab=Di[23]}
N 3340 -3210 3360 -3210 {
lab=Di[24]}
N 3340 -3190 3360 -3190 {
lab=Di[25]}
N 3340 -3170 3360 -3170 {
lab=Di[26]}
N 3340 -3150 3360 -3150 {
lab=Di[27]}
N 3340 -3130 3360 -3130 {
lab=Di[28]}
N 3340 -3110 3360 -3110 {
lab=Di[29]}
N 3340 -3090 3360 -3090 {
lab=Di[30]}
N 3340 -3070 3360 -3070 {
lab=Di[31]}
N 3430 -3750 3430 -3730 {
lab=CLK_buf}
N 3450 -3750 3450 -3730 {
lab=SEL1}
N 3470 -3750 3470 -3730 {
lab=we0_buf}
N 3490 -3750 3490 -3730 {
lab=we1_buf}
N 3510 -3750 3510 -3730 {
lab=we2_buf}
N 3530 -3750 3530 -3730 {
lab=we3_buf}
N 3560 -3750 3560 -3730 {
lab=VDD}
N 3580 -3750 3580 -3730 {
lab=VSS}
N 3880 -3690 3900 -3690 {
lab=di0_buf}
N 3880 -3670 3900 -3670 {
lab=di1_buf}
N 3880 -3650 3900 -3650 {
lab=di2_buf}
N 3880 -3630 3900 -3630 {
lab=di3_buf}
N 3880 -3610 3900 -3610 {
lab=di4_buf}
N 3880 -3590 3900 -3590 {
lab=di5_buf}
N 3880 -3570 3900 -3570 {
lab=di6_buf}
N 3880 -3550 3900 -3550 {
lab=di7_buf}
N 3880 -3530 3900 -3530 {
lab=di8_buf}
N 3880 -3510 3900 -3510 {
lab=di9_buf}
N 3880 -3490 3900 -3490 {
lab=di10_buf}
N 3880 -3470 3900 -3470 {
lab=di11_buf}
N 3880 -3450 3900 -3450 {
lab=di12_buf}
N 3880 -3430 3900 -3430 {
lab=di13_buf}
N 3880 -3410 3900 -3410 {
lab=di14_buf}
N 3880 -3390 3900 -3390 {
lab=di15_buf}
N 3880 -3370 3900 -3370 {
lab=di16_buf}
N 3880 -3350 3900 -3350 {
lab=Di[17]}
N 3880 -3330 3900 -3330 {
lab=Di[18]}
N 3880 -3310 3900 -3310 {
lab=Di[19]}
N 3880 -3290 3900 -3290 {
lab=Di[20]}
N 3880 -3270 3900 -3270 {
lab=Di[21]}
N 3880 -3250 3900 -3250 {
lab=Di[22]}
N 3880 -3230 3900 -3230 {
lab=Di[23]}
N 3880 -3210 3900 -3210 {
lab=Di[24]}
N 3880 -3190 3900 -3190 {
lab=Di[25]}
N 3880 -3170 3900 -3170 {
lab=Di[26]}
N 3880 -3150 3900 -3150 {
lab=Di[27]}
N 3880 -3130 3900 -3130 {
lab=Di[28]}
N 3880 -3110 3900 -3110 {
lab=Di[29]}
N 3880 -3090 3900 -3090 {
lab=Di[30]}
N 3880 -3070 3900 -3070 {
lab=Di[31]}
N 3970 -3750 3970 -3730 {
lab=CLK_buf}
N 3990 -3750 3990 -3730 {
lab=SEL[2]}
N 4010 -3750 4010 -3730 {
lab=we0_buf}
N 4030 -3750 4030 -3730 {
lab=we1_buf}
N 4050 -3750 4050 -3730 {
lab=we2_buf}
N 4070 -3750 4070 -3730 {
lab=we3_buf}
N 4100 -3750 4100 -3730 {
lab=VDD}
N 4120 -3750 4120 -3730 {
lab=VSS}
N 4400 -3690 4420 -3690 {
lab=di0_buf}
N 4400 -3670 4420 -3670 {
lab=di1_buf}
N 4400 -3650 4420 -3650 {
lab=di2_buf}
N 4400 -3630 4420 -3630 {
lab=di3_buf}
N 4400 -3610 4420 -3610 {
lab=di4_buf}
N 4400 -3590 4420 -3590 {
lab=di5_buf}
N 4400 -3570 4420 -3570 {
lab=di6_buf}
N 4400 -3550 4420 -3550 {
lab=di7_buf}
N 4400 -3530 4420 -3530 {
lab=di8_buf}
N 4400 -3510 4420 -3510 {
lab=di9_buf}
N 4400 -3490 4420 -3490 {
lab=di10_buf}
N 4400 -3470 4420 -3470 {
lab=di11_buf}
N 4400 -3450 4420 -3450 {
lab=di12_buf}
N 4400 -3430 4420 -3430 {
lab=di13_buf}
N 4400 -3410 4420 -3410 {
lab=di14_buf}
N 4400 -3390 4420 -3390 {
lab=di15_buf}
N 4400 -3370 4420 -3370 {
lab=di16_buf}
N 4400 -3350 4420 -3350 {
lab=Di[17]}
N 4400 -3330 4420 -3330 {
lab=Di[18]}
N 4400 -3310 4420 -3310 {
lab=Di[19]}
N 4400 -3290 4420 -3290 {
lab=Di[20]}
N 4400 -3270 4420 -3270 {
lab=Di[21]}
N 4400 -3250 4420 -3250 {
lab=Di[22]}
N 4400 -3230 4420 -3230 {
lab=Di[23]}
N 4400 -3210 4420 -3210 {
lab=Di[24]}
N 4400 -3190 4420 -3190 {
lab=Di[25]}
N 4400 -3170 4420 -3170 {
lab=Di[26]}
N 4400 -3150 4420 -3150 {
lab=Di[27]}
N 4400 -3130 4420 -3130 {
lab=Di[28]}
N 4400 -3110 4420 -3110 {
lab=Di[29]}
N 4400 -3090 4420 -3090 {
lab=Di[30]}
N 4400 -3070 4420 -3070 {
lab=Di[31]}
N 4490 -3750 4490 -3730 {
lab=CLK_buf}
N 4510 -3750 4510 -3730 {
lab=SEL[3]}
N 4530 -3750 4530 -3730 {
lab=we0_buf}
N 4550 -3750 4550 -3730 {
lab=we1_buf}
N 4570 -3750 4570 -3730 {
lab=we2_buf}
N 4590 -3750 4590 -3730 {
lab=we3_buf}
N 4620 -3750 4620 -3730 {
lab=VDD}
N 4640 -3750 4640 -3730 {
lab=VSS}
N 4920 -3690 4940 -3690 {
lab=di0_buf}
N 4920 -3670 4940 -3670 {
lab=di1_buf}
N 4920 -3650 4940 -3650 {
lab=di2_buf}
N 4920 -3630 4940 -3630 {
lab=di3_buf}
N 4920 -3610 4940 -3610 {
lab=di4_buf}
N 4920 -3590 4940 -3590 {
lab=di5_buf}
N 4920 -3570 4940 -3570 {
lab=di6_buf}
N 4920 -3550 4940 -3550 {
lab=di7_buf}
N 4920 -3530 4940 -3530 {
lab=di8_buf}
N 4920 -3510 4940 -3510 {
lab=di9_buf}
N 4920 -3490 4940 -3490 {
lab=di10_buf}
N 4920 -3470 4940 -3470 {
lab=di11_buf}
N 4920 -3450 4940 -3450 {
lab=di12_buf}
N 4920 -3430 4940 -3430 {
lab=di13_buf}
N 4920 -3410 4940 -3410 {
lab=di14_buf}
N 4920 -3390 4940 -3390 {
lab=di15_buf}
N 4920 -3370 4940 -3370 {
lab=di16_buf}
N 4920 -3350 4940 -3350 {
lab=Di[17]}
N 4920 -3330 4940 -3330 {
lab=Di[18]}
N 4920 -3310 4940 -3310 {
lab=Di[19]}
N 4920 -3290 4940 -3290 {
lab=Di[20]}
N 4920 -3270 4940 -3270 {
lab=Di[21]}
N 4920 -3250 4940 -3250 {
lab=Di[22]}
N 4920 -3230 4940 -3230 {
lab=Di[23]}
N 4920 -3210 4940 -3210 {
lab=Di[24]}
N 4920 -3190 4940 -3190 {
lab=Di[25]}
N 4920 -3170 4940 -3170 {
lab=Di[26]}
N 4920 -3150 4940 -3150 {
lab=Di[27]}
N 4920 -3130 4940 -3130 {
lab=Di[28]}
N 4920 -3110 4940 -3110 {
lab=Di[29]}
N 4920 -3090 4940 -3090 {
lab=Di[30]}
N 4920 -3070 4940 -3070 {
lab=Di[31]}
N 5010 -3750 5010 -3730 {
lab=CLK_buf}
N 5030 -3750 5030 -3730 {
lab=SEL[4]}
N 5050 -3750 5050 -3730 {
lab=we0_buf}
N 5070 -3750 5070 -3730 {
lab=we1_buf}
N 5090 -3750 5090 -3730 {
lab=we2_buf}
N 5110 -3750 5110 -3730 {
lab=we3_buf}
N 5140 -3750 5140 -3730 {
lab=VDD}
N 5160 -3750 5160 -3730 {
lab=VSS}
N 5440 -3690 5460 -3690 {
lab=di0_buf}
N 5440 -3670 5460 -3670 {
lab=di1_buf}
N 5440 -3650 5460 -3650 {
lab=di2_buf}
N 5440 -3630 5460 -3630 {
lab=di3_buf}
N 5440 -3610 5460 -3610 {
lab=di4_buf}
N 5440 -3590 5460 -3590 {
lab=di5_buf}
N 5440 -3570 5460 -3570 {
lab=di6_buf}
N 5440 -3550 5460 -3550 {
lab=di7_buf}
N 5440 -3530 5460 -3530 {
lab=di8_buf}
N 5440 -3510 5460 -3510 {
lab=di9_buf}
N 5440 -3490 5460 -3490 {
lab=di10_buf}
N 5440 -3470 5460 -3470 {
lab=di11_buf}
N 5440 -3450 5460 -3450 {
lab=di12_buf}
N 5440 -3430 5460 -3430 {
lab=di13_buf}
N 5440 -3410 5460 -3410 {
lab=di14_buf}
N 5440 -3390 5460 -3390 {
lab=di15_buf}
N 5440 -3370 5460 -3370 {
lab=di16_buf}
N 5440 -3350 5460 -3350 {
lab=Di[17]}
N 5440 -3330 5460 -3330 {
lab=Di[18]}
N 5440 -3310 5460 -3310 {
lab=Di[19]}
N 5440 -3290 5460 -3290 {
lab=Di[20]}
N 5440 -3270 5460 -3270 {
lab=Di[21]}
N 5440 -3250 5460 -3250 {
lab=Di[22]}
N 5440 -3230 5460 -3230 {
lab=Di[23]}
N 5440 -3210 5460 -3210 {
lab=Di[24]}
N 5440 -3190 5460 -3190 {
lab=Di[25]}
N 5440 -3170 5460 -3170 {
lab=Di[26]}
N 5440 -3150 5460 -3150 {
lab=Di[27]}
N 5440 -3130 5460 -3130 {
lab=Di[28]}
N 5440 -3110 5460 -3110 {
lab=Di[29]}
N 5440 -3090 5460 -3090 {
lab=Di[30]}
N 5440 -3070 5460 -3070 {
lab=Di[31]}
N 5530 -3750 5530 -3730 {
lab=CLK_buf}
N 5550 -3750 5550 -3730 {
lab=SEL[5]}
N 5570 -3750 5570 -3730 {
lab=we0_buf}
N 5590 -3750 5590 -3730 {
lab=we1_buf}
N 5610 -3750 5610 -3730 {
lab=we2_buf}
N 5630 -3750 5630 -3730 {
lab=we3_buf}
N 5660 -3750 5660 -3730 {
lab=VDD}
N 5680 -3750 5680 -3730 {
lab=VSS}
N 5980 -3690 6000 -3690 {
lab=di0_buf}
N 5980 -3670 6000 -3670 {
lab=di1_buf}
N 5980 -3650 6000 -3650 {
lab=di2_buf}
N 5980 -3630 6000 -3630 {
lab=di3_buf}
N 5980 -3610 6000 -3610 {
lab=di4_buf}
N 5980 -3590 6000 -3590 {
lab=di5_buf}
N 5980 -3570 6000 -3570 {
lab=di6_buf}
N 5980 -3550 6000 -3550 {
lab=di7_buf}
N 5980 -3530 6000 -3530 {
lab=di8_buf}
N 5980 -3510 6000 -3510 {
lab=di9_buf}
N 5980 -3490 6000 -3490 {
lab=di10_buf}
N 5980 -3470 6000 -3470 {
lab=di11_buf}
N 5980 -3450 6000 -3450 {
lab=di12_buf}
N 5980 -3430 6000 -3430 {
lab=di13_buf}
N 5980 -3410 6000 -3410 {
lab=di14_buf}
N 5980 -3390 6000 -3390 {
lab=di15_buf}
N 5980 -3370 6000 -3370 {
lab=di16_buf}
N 5980 -3350 6000 -3350 {
lab=Di[17]}
N 5980 -3330 6000 -3330 {
lab=Di[18]}
N 5980 -3310 6000 -3310 {
lab=Di[19]}
N 5980 -3290 6000 -3290 {
lab=Di[20]}
N 5980 -3270 6000 -3270 {
lab=Di[21]}
N 5980 -3250 6000 -3250 {
lab=Di[22]}
N 5980 -3230 6000 -3230 {
lab=Di[23]}
N 5980 -3210 6000 -3210 {
lab=Di[24]}
N 5980 -3190 6000 -3190 {
lab=Di[25]}
N 5980 -3170 6000 -3170 {
lab=Di[26]}
N 5980 -3150 6000 -3150 {
lab=Di[27]}
N 5980 -3130 6000 -3130 {
lab=Di[28]}
N 5980 -3110 6000 -3110 {
lab=Di[29]}
N 5980 -3090 6000 -3090 {
lab=Di[30]}
N 5980 -3070 6000 -3070 {
lab=Di[31]}
N 6070 -3750 6070 -3730 {
lab=CLK_buf}
N 6090 -3750 6090 -3730 {
lab=SEL[6]}
N 6110 -3750 6110 -3730 {
lab=we0_buf}
N 6130 -3750 6130 -3730 {
lab=we1_buf}
N 6150 -3750 6150 -3730 {
lab=we2_buf}
N 6170 -3750 6170 -3730 {
lab=we3_buf}
N 6200 -3750 6200 -3730 {
lab=VDD}
N 6220 -3750 6220 -3730 {
lab=VSS}
N 6500 -3690 6520 -3690 {
lab=di0_buf}
N 6500 -3670 6520 -3670 {
lab=di1_buf}
N 6500 -3650 6520 -3650 {
lab=di2_buf}
N 6500 -3630 6520 -3630 {
lab=di3_buf}
N 6500 -3610 6520 -3610 {
lab=di4_buf}
N 6500 -3590 6520 -3590 {
lab=di5_buf}
N 6500 -3570 6520 -3570 {
lab=di6_buf}
N 6500 -3550 6520 -3550 {
lab=di7_buf}
N 6500 -3530 6520 -3530 {
lab=di8_buf}
N 6500 -3510 6520 -3510 {
lab=di9_buf}
N 6500 -3490 6520 -3490 {
lab=di10_buf}
N 6500 -3470 6520 -3470 {
lab=di11_buf}
N 6500 -3450 6520 -3450 {
lab=di12_buf}
N 6500 -3430 6520 -3430 {
lab=di13_buf}
N 6500 -3410 6520 -3410 {
lab=di14_buf}
N 6500 -3390 6520 -3390 {
lab=di15_buf}
N 6500 -3370 6520 -3370 {
lab=di16_buf}
N 6500 -3350 6520 -3350 {
lab=Di[17]}
N 6500 -3330 6520 -3330 {
lab=Di[18]}
N 6500 -3310 6520 -3310 {
lab=Di[19]}
N 6500 -3290 6520 -3290 {
lab=Di[20]}
N 6500 -3270 6520 -3270 {
lab=Di[21]}
N 6500 -3250 6520 -3250 {
lab=Di[22]}
N 6500 -3230 6520 -3230 {
lab=Di[23]}
N 6500 -3210 6520 -3210 {
lab=Di[24]}
N 6500 -3190 6520 -3190 {
lab=Di[25]}
N 6500 -3170 6520 -3170 {
lab=Di[26]}
N 6500 -3150 6520 -3150 {
lab=Di[27]}
N 6500 -3130 6520 -3130 {
lab=Di[28]}
N 6500 -3110 6520 -3110 {
lab=Di[29]}
N 6500 -3090 6520 -3090 {
lab=Di[30]}
N 6500 -3070 6520 -3070 {
lab=Di[31]}
N 6590 -3750 6590 -3730 {
lab=CLK_buf}
N 6610 -3750 6610 -3730 {
lab=SEL[7]}
N 6630 -3750 6630 -3730 {
lab=we0_buf}
N 6650 -3750 6650 -3730 {
lab=we1_buf}
N 6670 -3750 6670 -3730 {
lab=we2_buf}
N 6690 -3750 6690 -3730 {
lab=we3_buf}
N 6720 -3750 6720 -3730 {
lab=VDD}
N 6740 -3750 6740 -3730 {
lab=VSS}
N 6500 -2790 6520 -2790 {
lab=di0_buf}
N 6500 -2770 6520 -2770 {
lab=di1_buf}
N 6500 -2750 6520 -2750 {
lab=di2_buf}
N 6500 -2730 6520 -2730 {
lab=di3_buf}
N 6500 -2710 6520 -2710 {
lab=di4_buf}
N 6500 -2690 6520 -2690 {
lab=di5_buf}
N 6500 -2670 6520 -2670 {
lab=di6_buf}
N 6500 -2650 6520 -2650 {
lab=di7_buf}
N 6500 -2630 6520 -2630 {
lab=di8_buf}
N 6500 -2610 6520 -2610 {
lab=di9_buf}
N 6500 -2590 6520 -2590 {
lab=di10_buf}
N 6500 -2570 6520 -2570 {
lab=di11_buf}
N 6500 -2550 6520 -2550 {
lab=di12_buf}
N 6500 -2530 6520 -2530 {
lab=di13_buf}
N 6500 -2510 6520 -2510 {
lab=di14_buf}
N 6500 -2490 6520 -2490 {
lab=di15_buf}
N 6500 -2470 6520 -2470 {
lab=di16_buf}
N 6500 -2450 6520 -2450 {
lab=Di[17]}
N 6500 -2430 6520 -2430 {
lab=Di[18]}
N 6500 -2410 6520 -2410 {
lab=Di[19]}
N 6500 -2390 6520 -2390 {
lab=Di[20]}
N 6500 -2370 6520 -2370 {
lab=Di[21]}
N 6500 -2350 6520 -2350 {
lab=Di[22]}
N 6500 -2330 6520 -2330 {
lab=Di[23]}
N 6500 -2310 6520 -2310 {
lab=Di[24]}
N 6500 -2290 6520 -2290 {
lab=Di[25]}
N 6500 -2270 6520 -2270 {
lab=Di[26]}
N 6500 -2250 6520 -2250 {
lab=Di[27]}
N 6500 -2230 6520 -2230 {
lab=Di[28]}
N 6500 -2210 6520 -2210 {
lab=Di[29]}
N 6500 -2190 6520 -2190 {
lab=Di[30]}
N 6500 -2170 6520 -2170 {
lab=Di[31]}
N 6590 -2850 6590 -2830 {
lab=CLK_buf}
N 6610 -2850 6610 -2830 {
lab=SEL[15]}
N 6630 -2850 6630 -2830 {
lab=we0_buf}
N 6650 -2850 6650 -2830 {
lab=we1_buf}
N 6670 -2850 6670 -2830 {
lab=we2_buf}
N 6690 -2850 6690 -2830 {
lab=we3_buf}
N 6720 -2850 6720 -2830 {
lab=VDD}
N 6740 -2850 6740 -2830 {
lab=VSS}
N 5980 -2790 6000 -2790 {
lab=di0_buf}
N 5980 -2770 6000 -2770 {
lab=di1_buf}
N 5980 -2750 6000 -2750 {
lab=di2_buf}
N 5980 -2730 6000 -2730 {
lab=di3_buf}
N 5980 -2710 6000 -2710 {
lab=di4_buf}
N 5980 -2690 6000 -2690 {
lab=di5_buf}
N 5980 -2670 6000 -2670 {
lab=di6_buf}
N 5980 -2650 6000 -2650 {
lab=di7_buf}
N 5980 -2630 6000 -2630 {
lab=di8_buf}
N 5980 -2610 6000 -2610 {
lab=di9_buf}
N 5980 -2590 6000 -2590 {
lab=di10_buf}
N 5980 -2570 6000 -2570 {
lab=di11_buf}
N 5980 -2550 6000 -2550 {
lab=di12_buf}
N 5980 -2530 6000 -2530 {
lab=di13_buf}
N 5980 -2510 6000 -2510 {
lab=di14_buf}
N 5980 -2490 6000 -2490 {
lab=di15_buf}
N 5980 -2470 6000 -2470 {
lab=di16_buf}
N 5980 -2450 6000 -2450 {
lab=Di[17]}
N 5980 -2430 6000 -2430 {
lab=Di[18]}
N 5980 -2410 6000 -2410 {
lab=Di[19]}
N 5980 -2390 6000 -2390 {
lab=Di[20]}
N 5980 -2370 6000 -2370 {
lab=Di[21]}
N 5980 -2350 6000 -2350 {
lab=Di[22]}
N 5980 -2330 6000 -2330 {
lab=Di[23]}
N 5980 -2310 6000 -2310 {
lab=Di[24]}
N 5980 -2290 6000 -2290 {
lab=Di[25]}
N 5980 -2270 6000 -2270 {
lab=Di[26]}
N 5980 -2250 6000 -2250 {
lab=Di[27]}
N 5980 -2230 6000 -2230 {
lab=Di[28]}
N 5980 -2210 6000 -2210 {
lab=Di[29]}
N 5980 -2190 6000 -2190 {
lab=Di[30]}
N 5980 -2170 6000 -2170 {
lab=Di[31]}
N 6070 -2850 6070 -2830 {
lab=CLK_buf}
N 6090 -2850 6090 -2830 {
lab=SEL[14]}
N 6110 -2850 6110 -2830 {
lab=we0_buf}
N 6130 -2850 6130 -2830 {
lab=we1_buf}
N 6150 -2850 6150 -2830 {
lab=we2_buf}
N 6170 -2850 6170 -2830 {
lab=we3_buf}
N 6200 -2850 6200 -2830 {
lab=VDD}
N 6220 -2850 6220 -2830 {
lab=VSS}
N 5440 -2790 5460 -2790 {
lab=di0_buf}
N 5440 -2770 5460 -2770 {
lab=di1_buf}
N 5440 -2750 5460 -2750 {
lab=di2_buf}
N 5440 -2730 5460 -2730 {
lab=di3_buf}
N 5440 -2710 5460 -2710 {
lab=di4_buf}
N 5440 -2690 5460 -2690 {
lab=di5_buf}
N 5440 -2670 5460 -2670 {
lab=di6_buf}
N 5440 -2650 5460 -2650 {
lab=di7_buf}
N 5440 -2630 5460 -2630 {
lab=di8_buf}
N 5440 -2610 5460 -2610 {
lab=di9_buf}
N 5440 -2590 5460 -2590 {
lab=di10_buf}
N 5440 -2570 5460 -2570 {
lab=di11_buf}
N 5440 -2550 5460 -2550 {
lab=di12_buf}
N 5440 -2530 5460 -2530 {
lab=di13_buf}
N 5440 -2510 5460 -2510 {
lab=di14_buf}
N 5440 -2490 5460 -2490 {
lab=di15_buf}
N 5440 -2470 5460 -2470 {
lab=di16_buf}
N 5440 -2450 5460 -2450 {
lab=Di[17]}
N 5440 -2430 5460 -2430 {
lab=Di[18]}
N 5440 -2410 5460 -2410 {
lab=Di[19]}
N 5440 -2390 5460 -2390 {
lab=Di[20]}
N 5440 -2370 5460 -2370 {
lab=Di[21]}
N 5440 -2350 5460 -2350 {
lab=Di[22]}
N 5440 -2330 5460 -2330 {
lab=Di[23]}
N 5440 -2310 5460 -2310 {
lab=Di[24]}
N 5440 -2290 5460 -2290 {
lab=Di[25]}
N 5440 -2270 5460 -2270 {
lab=Di[26]}
N 5440 -2250 5460 -2250 {
lab=Di[27]}
N 5440 -2230 5460 -2230 {
lab=Di[28]}
N 5440 -2210 5460 -2210 {
lab=Di[29]}
N 5440 -2190 5460 -2190 {
lab=Di[30]}
N 5440 -2170 5460 -2170 {
lab=Di[31]}
N 5530 -2850 5530 -2830 {
lab=CLK_buf}
N 5550 -2850 5550 -2830 {
lab=SEL[13]}
N 5570 -2850 5570 -2830 {
lab=we0_buf}
N 5590 -2850 5590 -2830 {
lab=we1_buf}
N 5610 -2850 5610 -2830 {
lab=we2_buf}
N 5630 -2850 5630 -2830 {
lab=we3_buf}
N 5660 -2850 5660 -2830 {
lab=VDD}
N 5680 -2850 5680 -2830 {
lab=VSS}
N 4920 -2790 4940 -2790 {
lab=di0_buf}
N 4920 -2770 4940 -2770 {
lab=di1_buf}
N 4920 -2750 4940 -2750 {
lab=di2_buf}
N 4920 -2730 4940 -2730 {
lab=di3_buf}
N 4920 -2710 4940 -2710 {
lab=di4_buf}
N 4920 -2690 4940 -2690 {
lab=di5_buf}
N 4920 -2670 4940 -2670 {
lab=di6_buf}
N 4920 -2650 4940 -2650 {
lab=di7_buf}
N 4920 -2630 4940 -2630 {
lab=di8_buf}
N 4920 -2610 4940 -2610 {
lab=di9_buf}
N 4920 -2590 4940 -2590 {
lab=di10_buf}
N 4920 -2570 4940 -2570 {
lab=di11_buf}
N 4920 -2550 4940 -2550 {
lab=di12_buf}
N 4920 -2530 4940 -2530 {
lab=di13_buf}
N 4920 -2510 4940 -2510 {
lab=di14_buf}
N 4920 -2490 4940 -2490 {
lab=di15_buf}
N 4920 -2470 4940 -2470 {
lab=di16_buf}
N 4920 -2450 4940 -2450 {
lab=Di[17]}
N 4920 -2430 4940 -2430 {
lab=Di[18]}
N 4920 -2410 4940 -2410 {
lab=Di[19]}
N 4920 -2390 4940 -2390 {
lab=Di[20]}
N 4920 -2370 4940 -2370 {
lab=Di[21]}
N 4920 -2350 4940 -2350 {
lab=Di[22]}
N 4920 -2330 4940 -2330 {
lab=Di[23]}
N 4920 -2310 4940 -2310 {
lab=Di[24]}
N 4920 -2290 4940 -2290 {
lab=Di[25]}
N 4920 -2270 4940 -2270 {
lab=Di[26]}
N 4920 -2250 4940 -2250 {
lab=Di[27]}
N 4920 -2230 4940 -2230 {
lab=Di[28]}
N 4920 -2210 4940 -2210 {
lab=Di[29]}
N 4920 -2190 4940 -2190 {
lab=Di[30]}
N 4920 -2170 4940 -2170 {
lab=Di[31]}
N 5010 -2850 5010 -2830 {
lab=CLK_buf}
N 5030 -2850 5030 -2830 {
lab=SEL[12]}
N 5050 -2850 5050 -2830 {
lab=we0_buf}
N 5070 -2850 5070 -2830 {
lab=we1_buf}
N 5090 -2850 5090 -2830 {
lab=we2_buf}
N 5110 -2850 5110 -2830 {
lab=we3_buf}
N 5140 -2850 5140 -2830 {
lab=VDD}
N 5160 -2850 5160 -2830 {
lab=VSS}
N 4400 -2790 4420 -2790 {
lab=di0_buf}
N 4400 -2770 4420 -2770 {
lab=di1_buf}
N 4400 -2750 4420 -2750 {
lab=di2_buf}
N 4400 -2730 4420 -2730 {
lab=di3_buf}
N 4400 -2710 4420 -2710 {
lab=di4_buf}
N 4400 -2690 4420 -2690 {
lab=di5_buf}
N 4400 -2670 4420 -2670 {
lab=di6_buf}
N 4400 -2650 4420 -2650 {
lab=di7_buf}
N 4400 -2630 4420 -2630 {
lab=di8_buf}
N 4400 -2610 4420 -2610 {
lab=di9_buf}
N 4400 -2590 4420 -2590 {
lab=di10_buf}
N 4400 -2570 4420 -2570 {
lab=di11_buf}
N 4400 -2550 4420 -2550 {
lab=di12_buf}
N 4400 -2530 4420 -2530 {
lab=di13_buf}
N 4400 -2510 4420 -2510 {
lab=di14_buf}
N 4400 -2490 4420 -2490 {
lab=di15_buf}
N 4400 -2470 4420 -2470 {
lab=di16_buf}
N 4400 -2450 4420 -2450 {
lab=Di[17]}
N 4400 -2430 4420 -2430 {
lab=Di[18]}
N 4400 -2410 4420 -2410 {
lab=Di[19]}
N 4400 -2390 4420 -2390 {
lab=Di[20]}
N 4400 -2370 4420 -2370 {
lab=Di[21]}
N 4400 -2350 4420 -2350 {
lab=Di[22]}
N 4400 -2330 4420 -2330 {
lab=Di[23]}
N 4400 -2310 4420 -2310 {
lab=Di[24]}
N 4400 -2290 4420 -2290 {
lab=Di[25]}
N 4400 -2270 4420 -2270 {
lab=Di[26]}
N 4400 -2250 4420 -2250 {
lab=Di[27]}
N 4400 -2230 4420 -2230 {
lab=Di[28]}
N 4400 -2210 4420 -2210 {
lab=Di[29]}
N 4400 -2190 4420 -2190 {
lab=Di[30]}
N 4400 -2170 4420 -2170 {
lab=Di[31]}
N 4490 -2850 4490 -2830 {
lab=CLK_buf}
N 4510 -2850 4510 -2830 {
lab=SEL[11]}
N 4530 -2850 4530 -2830 {
lab=we0_buf}
N 4550 -2850 4550 -2830 {
lab=we1_buf}
N 4570 -2850 4570 -2830 {
lab=we2_buf}
N 4590 -2850 4590 -2830 {
lab=we3_buf}
N 4620 -2850 4620 -2830 {
lab=VDD}
N 4640 -2850 4640 -2830 {
lab=VSS}
N 3880 -2790 3900 -2790 {
lab=di0_buf}
N 3880 -2770 3900 -2770 {
lab=di1_buf}
N 3880 -2750 3900 -2750 {
lab=di2_buf}
N 3880 -2730 3900 -2730 {
lab=di3_buf}
N 3880 -2710 3900 -2710 {
lab=di4_buf}
N 3880 -2690 3900 -2690 {
lab=di5_buf}
N 3880 -2670 3900 -2670 {
lab=di6_buf}
N 3880 -2650 3900 -2650 {
lab=di7_buf}
N 3880 -2630 3900 -2630 {
lab=di8_buf}
N 3880 -2610 3900 -2610 {
lab=di9_buf}
N 3880 -2590 3900 -2590 {
lab=di10_buf}
N 3880 -2570 3900 -2570 {
lab=di11_buf}
N 3880 -2550 3900 -2550 {
lab=di12_buf}
N 3880 -2530 3900 -2530 {
lab=di13_buf}
N 3880 -2510 3900 -2510 {
lab=di14_buf}
N 3880 -2490 3900 -2490 {
lab=di15_buf}
N 3880 -2470 3900 -2470 {
lab=di16_buf}
N 3880 -2450 3900 -2450 {
lab=Di[17]}
N 3880 -2430 3900 -2430 {
lab=Di[18]}
N 3880 -2410 3900 -2410 {
lab=Di[19]}
N 3880 -2390 3900 -2390 {
lab=Di[20]}
N 3880 -2370 3900 -2370 {
lab=Di[21]}
N 3880 -2350 3900 -2350 {
lab=Di[22]}
N 3880 -2330 3900 -2330 {
lab=Di[23]}
N 3880 -2310 3900 -2310 {
lab=Di[24]}
N 3880 -2290 3900 -2290 {
lab=Di[25]}
N 3880 -2270 3900 -2270 {
lab=Di[26]}
N 3880 -2250 3900 -2250 {
lab=Di[27]}
N 3880 -2230 3900 -2230 {
lab=Di[28]}
N 3880 -2210 3900 -2210 {
lab=Di[29]}
N 3880 -2190 3900 -2190 {
lab=Di[30]}
N 3880 -2170 3900 -2170 {
lab=Di[31]}
N 3970 -2850 3970 -2830 {
lab=CLK_buf}
N 3990 -2850 3990 -2830 {
lab=SEL[10]}
N 4010 -2850 4010 -2830 {
lab=we0_buf}
N 4030 -2850 4030 -2830 {
lab=we1_buf}
N 4050 -2850 4050 -2830 {
lab=we2_buf}
N 4070 -2850 4070 -2830 {
lab=we3_buf}
N 4100 -2850 4100 -2830 {
lab=VDD}
N 4120 -2850 4120 -2830 {
lab=VSS}
N 3340 -2790 3360 -2790 {
lab=di0_buf}
N 3340 -2770 3360 -2770 {
lab=di1_buf}
N 3340 -2750 3360 -2750 {
lab=di2_buf}
N 3340 -2730 3360 -2730 {
lab=di3_buf}
N 3340 -2710 3360 -2710 {
lab=di4_buf}
N 3340 -2690 3360 -2690 {
lab=di5_buf}
N 3340 -2670 3360 -2670 {
lab=di6_buf}
N 3340 -2650 3360 -2650 {
lab=di7_buf}
N 3340 -2630 3360 -2630 {
lab=di8_buf}
N 3340 -2610 3360 -2610 {
lab=di9_buf}
N 3340 -2590 3360 -2590 {
lab=di10_buf}
N 3340 -2570 3360 -2570 {
lab=di11_buf}
N 3340 -2550 3360 -2550 {
lab=di12_buf}
N 3340 -2530 3360 -2530 {
lab=di13_buf}
N 3340 -2510 3360 -2510 {
lab=di14_buf}
N 3340 -2490 3360 -2490 {
lab=di15_buf}
N 3340 -2470 3360 -2470 {
lab=di16_buf}
N 3340 -2450 3360 -2450 {
lab=Di[17]}
N 3340 -2430 3360 -2430 {
lab=Di[18]}
N 3340 -2410 3360 -2410 {
lab=Di[19]}
N 3340 -2390 3360 -2390 {
lab=Di[20]}
N 3340 -2370 3360 -2370 {
lab=Di[21]}
N 3340 -2350 3360 -2350 {
lab=Di[22]}
N 3340 -2330 3360 -2330 {
lab=Di[23]}
N 3340 -2310 3360 -2310 {
lab=Di[24]}
N 3340 -2290 3360 -2290 {
lab=Di[25]}
N 3340 -2270 3360 -2270 {
lab=Di[26]}
N 3340 -2250 3360 -2250 {
lab=Di[27]}
N 3340 -2230 3360 -2230 {
lab=Di[28]}
N 3340 -2210 3360 -2210 {
lab=Di[29]}
N 3340 -2190 3360 -2190 {
lab=Di[30]}
N 3340 -2170 3360 -2170 {
lab=Di[31]}
N 3430 -2850 3430 -2830 {
lab=CLK_buf}
N 3450 -2850 3450 -2830 {
lab=SEL[9]}
N 3470 -2850 3470 -2830 {
lab=we0_buf}
N 3490 -2850 3490 -2830 {
lab=we1_buf}
N 3510 -2850 3510 -2830 {
lab=we2_buf}
N 3530 -2850 3530 -2830 {
lab=we3_buf}
N 3560 -2850 3560 -2830 {
lab=VDD}
N 3580 -2850 3580 -2830 {
lab=VSS}
N 2820 -2790 2840 -2790 {
lab=di0_buf}
N 2820 -2770 2840 -2770 {
lab=di1_buf}
N 2820 -2750 2840 -2750 {
lab=di2_buf}
N 2820 -2730 2840 -2730 {
lab=di3_buf}
N 2820 -2710 2840 -2710 {
lab=di4_buf}
N 2820 -2690 2840 -2690 {
lab=di5_buf}
N 2820 -2670 2840 -2670 {
lab=di6_buf}
N 2820 -2650 2840 -2650 {
lab=di7_buf}
N 2820 -2630 2840 -2630 {
lab=di8_buf}
N 2820 -2610 2840 -2610 {
lab=di9_buf}
N 2820 -2590 2840 -2590 {
lab=di10_buf}
N 2820 -2570 2840 -2570 {
lab=di11_buf}
N 2820 -2550 2840 -2550 {
lab=di12_buf}
N 2820 -2530 2840 -2530 {
lab=di13_buf}
N 2820 -2510 2840 -2510 {
lab=di14_buf}
N 2820 -2490 2840 -2490 {
lab=di15_buf}
N 2820 -2470 2840 -2470 {
lab=di16_buf}
N 2820 -2450 2840 -2450 {
lab=Di[17]}
N 2820 -2430 2840 -2430 {
lab=Di[18]}
N 2820 -2410 2840 -2410 {
lab=Di[19]}
N 2820 -2390 2840 -2390 {
lab=Di[20]}
N 2820 -2370 2840 -2370 {
lab=Di[21]}
N 2820 -2350 2840 -2350 {
lab=Di[22]}
N 2820 -2330 2840 -2330 {
lab=Di[23]}
N 2820 -2310 2840 -2310 {
lab=Di[24]}
N 2820 -2290 2840 -2290 {
lab=Di[25]}
N 2820 -2270 2840 -2270 {
lab=Di[26]}
N 2820 -2250 2840 -2250 {
lab=Di[27]}
N 2820 -2230 2840 -2230 {
lab=Di[28]}
N 2820 -2210 2840 -2210 {
lab=Di[29]}
N 2820 -2190 2840 -2190 {
lab=Di[30]}
N 2820 -2170 2840 -2170 {
lab=Di[31]}
N 2910 -2850 2910 -2830 {
lab=CLK_buf}
N 2930 -2850 2930 -2830 {
lab=SEL[8]}
N 2950 -2850 2950 -2830 {
lab=we0_buf}
N 2970 -2850 2970 -2830 {
lab=we1_buf}
N 2990 -2850 2990 -2830 {
lab=we2_buf}
N 3010 -2850 3010 -2830 {
lab=we3_buf}
N 3040 -2850 3040 -2830 {
lab=VDD}
N 3060 -2850 3060 -2830 {
lab=VSS}
N 2830 -1840 2850 -1840 {
lab=di0_buf}
N 2830 -1820 2850 -1820 {
lab=di1_buf}
N 2830 -1800 2850 -1800 {
lab=di2_buf}
N 2830 -1780 2850 -1780 {
lab=di3_buf}
N 2830 -1760 2850 -1760 {
lab=di4_buf}
N 2830 -1740 2850 -1740 {
lab=di5_buf}
N 2830 -1720 2850 -1720 {
lab=di6_buf}
N 2830 -1700 2850 -1700 {
lab=di7_buf}
N 2830 -1680 2850 -1680 {
lab=di8_buf}
N 2830 -1660 2850 -1660 {
lab=di9_buf}
N 2830 -1640 2850 -1640 {
lab=di10_buf}
N 2830 -1620 2850 -1620 {
lab=di11_buf}
N 2830 -1600 2850 -1600 {
lab=di12_buf}
N 2830 -1580 2850 -1580 {
lab=di13_buf}
N 2830 -1560 2850 -1560 {
lab=di14_buf}
N 2830 -1540 2850 -1540 {
lab=di15_buf}
N 2830 -1520 2850 -1520 {
lab=di16_buf}
N 2830 -1500 2850 -1500 {
lab=Di[17]}
N 2830 -1480 2850 -1480 {
lab=Di[18]}
N 2830 -1460 2850 -1460 {
lab=Di[19]}
N 2830 -1440 2850 -1440 {
lab=Di[20]}
N 2830 -1420 2850 -1420 {
lab=Di[21]}
N 2830 -1400 2850 -1400 {
lab=Di[22]}
N 2830 -1380 2850 -1380 {
lab=Di[23]}
N 2830 -1360 2850 -1360 {
lab=Di[24]}
N 2830 -1340 2850 -1340 {
lab=Di[25]}
N 2830 -1320 2850 -1320 {
lab=Di[26]}
N 2830 -1300 2850 -1300 {
lab=Di[27]}
N 2830 -1280 2850 -1280 {
lab=Di[28]}
N 2830 -1260 2850 -1260 {
lab=Di[29]}
N 2830 -1240 2850 -1240 {
lab=Di[30]}
N 2830 -1220 2850 -1220 {
lab=Di[31]}
N 2920 -1900 2920 -1880 {
lab=CLK_buf}
N 2940 -1900 2940 -1880 {
lab=SEL[16]}
N 2960 -1900 2960 -1880 {
lab=we0_buf}
N 2980 -1900 2980 -1880 {
lab=we1_buf}
N 3000 -1900 3000 -1880 {
lab=we2_buf}
N 3020 -1900 3020 -1880 {
lab=we3_buf}
N 3050 -1900 3050 -1880 {
lab=VDD}
N 3070 -1900 3070 -1880 {
lab=VSS}
N 3350 -1840 3370 -1840 {
lab=di0_buf}
N 3350 -1820 3370 -1820 {
lab=di1_buf}
N 3350 -1800 3370 -1800 {
lab=di2_buf}
N 3350 -1780 3370 -1780 {
lab=di3_buf}
N 3350 -1760 3370 -1760 {
lab=di4_buf}
N 3350 -1740 3370 -1740 {
lab=di5_buf}
N 3350 -1720 3370 -1720 {
lab=di6_buf}
N 3350 -1700 3370 -1700 {
lab=di7_buf}
N 3350 -1680 3370 -1680 {
lab=di8_buf}
N 3350 -1660 3370 -1660 {
lab=di9_buf}
N 3350 -1640 3370 -1640 {
lab=di10_buf}
N 3350 -1620 3370 -1620 {
lab=di11_buf}
N 3350 -1600 3370 -1600 {
lab=di12_buf}
N 3350 -1580 3370 -1580 {
lab=di13_buf}
N 3350 -1560 3370 -1560 {
lab=di14_buf}
N 3350 -1540 3370 -1540 {
lab=di15_buf}
N 3350 -1520 3370 -1520 {
lab=di16_buf}
N 3350 -1500 3370 -1500 {
lab=Di[17]}
N 3350 -1480 3370 -1480 {
lab=Di[18]}
N 3350 -1460 3370 -1460 {
lab=Di[19]}
N 3350 -1440 3370 -1440 {
lab=Di[20]}
N 3350 -1420 3370 -1420 {
lab=Di[21]}
N 3350 -1400 3370 -1400 {
lab=Di[22]}
N 3350 -1380 3370 -1380 {
lab=Di[23]}
N 3350 -1360 3370 -1360 {
lab=Di[24]}
N 3350 -1340 3370 -1340 {
lab=Di[25]}
N 3350 -1320 3370 -1320 {
lab=Di[26]}
N 3350 -1300 3370 -1300 {
lab=Di[27]}
N 3350 -1280 3370 -1280 {
lab=Di[28]}
N 3350 -1260 3370 -1260 {
lab=Di[29]}
N 3350 -1240 3370 -1240 {
lab=Di[30]}
N 3350 -1220 3370 -1220 {
lab=Di[31]}
N 3440 -1900 3440 -1880 {
lab=CLK_buf}
N 3460 -1900 3460 -1880 {
lab=SEL[17]}
N 3480 -1900 3480 -1880 {
lab=we0_buf}
N 3500 -1900 3500 -1880 {
lab=we1_buf}
N 3520 -1900 3520 -1880 {
lab=we2_buf}
N 3540 -1900 3540 -1880 {
lab=we3_buf}
N 3570 -1900 3570 -1880 {
lab=VDD}
N 3590 -1900 3590 -1880 {
lab=VSS}
N 3890 -1840 3910 -1840 {
lab=di0_buf}
N 3890 -1820 3910 -1820 {
lab=di1_buf}
N 3890 -1800 3910 -1800 {
lab=di2_buf}
N 3890 -1780 3910 -1780 {
lab=di3_buf}
N 3890 -1760 3910 -1760 {
lab=di4_buf}
N 3890 -1740 3910 -1740 {
lab=di5_buf}
N 3890 -1720 3910 -1720 {
lab=di6_buf}
N 3890 -1700 3910 -1700 {
lab=di7_buf}
N 3890 -1680 3910 -1680 {
lab=di8_buf}
N 3890 -1660 3910 -1660 {
lab=di9_buf}
N 3890 -1640 3910 -1640 {
lab=di10_buf}
N 3890 -1620 3910 -1620 {
lab=di11_buf}
N 3890 -1600 3910 -1600 {
lab=di12_buf}
N 3890 -1580 3910 -1580 {
lab=di13_buf}
N 3890 -1560 3910 -1560 {
lab=di14_buf}
N 3890 -1540 3910 -1540 {
lab=di15_buf}
N 3890 -1520 3910 -1520 {
lab=di16_buf}
N 3890 -1500 3910 -1500 {
lab=Di[17]}
N 3890 -1480 3910 -1480 {
lab=Di[18]}
N 3890 -1460 3910 -1460 {
lab=Di[19]}
N 3890 -1440 3910 -1440 {
lab=Di[20]}
N 3890 -1420 3910 -1420 {
lab=Di[21]}
N 3890 -1400 3910 -1400 {
lab=Di[22]}
N 3890 -1380 3910 -1380 {
lab=Di[23]}
N 3890 -1360 3910 -1360 {
lab=Di[24]}
N 3890 -1340 3910 -1340 {
lab=Di[25]}
N 3890 -1320 3910 -1320 {
lab=Di[26]}
N 3890 -1300 3910 -1300 {
lab=Di[27]}
N 3890 -1280 3910 -1280 {
lab=Di[28]}
N 3890 -1260 3910 -1260 {
lab=Di[29]}
N 3890 -1240 3910 -1240 {
lab=Di[30]}
N 3890 -1220 3910 -1220 {
lab=Di[31]}
N 3980 -1900 3980 -1880 {
lab=CLK_buf}
N 4000 -1900 4000 -1880 {
lab=SEL[18]}
N 4020 -1900 4020 -1880 {
lab=we0_buf}
N 4040 -1900 4040 -1880 {
lab=we1_buf}
N 4060 -1900 4060 -1880 {
lab=we2_buf}
N 4080 -1900 4080 -1880 {
lab=we3_buf}
N 4110 -1900 4110 -1880 {
lab=VDD}
N 4130 -1900 4130 -1880 {
lab=VSS}
N 4410 -1840 4430 -1840 {
lab=di0_buf}
N 4410 -1820 4430 -1820 {
lab=di1_buf}
N 4410 -1800 4430 -1800 {
lab=di2_buf}
N 4410 -1780 4430 -1780 {
lab=di3_buf}
N 4410 -1760 4430 -1760 {
lab=di4_buf}
N 4410 -1740 4430 -1740 {
lab=di5_buf}
N 4410 -1720 4430 -1720 {
lab=di6_buf}
N 4410 -1700 4430 -1700 {
lab=di7_buf}
N 4410 -1680 4430 -1680 {
lab=di8_buf}
N 4410 -1660 4430 -1660 {
lab=di9_buf}
N 4410 -1640 4430 -1640 {
lab=di10_buf}
N 4410 -1620 4430 -1620 {
lab=di11_buf}
N 4410 -1600 4430 -1600 {
lab=di12_buf}
N 4410 -1580 4430 -1580 {
lab=di13_buf}
N 4410 -1560 4430 -1560 {
lab=di14_buf}
N 4410 -1540 4430 -1540 {
lab=di15_buf}
N 4410 -1520 4430 -1520 {
lab=di16_buf}
N 4410 -1500 4430 -1500 {
lab=Di[17]}
N 4410 -1480 4430 -1480 {
lab=Di[18]}
N 4410 -1460 4430 -1460 {
lab=Di[19]}
N 4410 -1440 4430 -1440 {
lab=Di[20]}
N 4410 -1420 4430 -1420 {
lab=Di[21]}
N 4410 -1400 4430 -1400 {
lab=Di[22]}
N 4410 -1380 4430 -1380 {
lab=Di[23]}
N 4410 -1360 4430 -1360 {
lab=Di[24]}
N 4410 -1340 4430 -1340 {
lab=Di[25]}
N 4410 -1320 4430 -1320 {
lab=Di[26]}
N 4410 -1300 4430 -1300 {
lab=Di[27]}
N 4410 -1280 4430 -1280 {
lab=Di[28]}
N 4410 -1260 4430 -1260 {
lab=Di[29]}
N 4410 -1240 4430 -1240 {
lab=Di[30]}
N 4410 -1220 4430 -1220 {
lab=Di[31]}
N 4500 -1900 4500 -1880 {
lab=CLK_buf}
N 4520 -1900 4520 -1880 {
lab=SEL[19]}
N 4540 -1900 4540 -1880 {
lab=we0_buf}
N 4560 -1900 4560 -1880 {
lab=we1_buf}
N 4580 -1900 4580 -1880 {
lab=we2_buf}
N 4600 -1900 4600 -1880 {
lab=we3_buf}
N 4630 -1900 4630 -1880 {
lab=VDD}
N 4650 -1900 4650 -1880 {
lab=VSS}
N 4930 -1840 4950 -1840 {
lab=di0_buf}
N 4930 -1820 4950 -1820 {
lab=di1_buf}
N 4930 -1800 4950 -1800 {
lab=di2_buf}
N 4930 -1780 4950 -1780 {
lab=di3_buf}
N 4930 -1760 4950 -1760 {
lab=di4_buf}
N 4930 -1740 4950 -1740 {
lab=di5_buf}
N 4930 -1720 4950 -1720 {
lab=di6_buf}
N 4930 -1700 4950 -1700 {
lab=di7_buf}
N 4930 -1680 4950 -1680 {
lab=di8_buf}
N 4930 -1660 4950 -1660 {
lab=di9_buf}
N 4930 -1640 4950 -1640 {
lab=di10_buf}
N 4930 -1620 4950 -1620 {
lab=di11_buf}
N 4930 -1600 4950 -1600 {
lab=di12_buf}
N 4930 -1580 4950 -1580 {
lab=di13_buf}
N 4930 -1560 4950 -1560 {
lab=di14_buf}
N 4930 -1540 4950 -1540 {
lab=di15_buf}
N 4930 -1520 4950 -1520 {
lab=di16_buf}
N 4930 -1500 4950 -1500 {
lab=Di[17]}
N 4930 -1480 4950 -1480 {
lab=Di[18]}
N 4930 -1460 4950 -1460 {
lab=Di[19]}
N 4930 -1440 4950 -1440 {
lab=Di[20]}
N 4930 -1420 4950 -1420 {
lab=Di[21]}
N 4930 -1400 4950 -1400 {
lab=Di[22]}
N 4930 -1380 4950 -1380 {
lab=Di[23]}
N 4930 -1360 4950 -1360 {
lab=Di[24]}
N 4930 -1340 4950 -1340 {
lab=Di[25]}
N 4930 -1320 4950 -1320 {
lab=Di[26]}
N 4930 -1300 4950 -1300 {
lab=Di[27]}
N 4930 -1280 4950 -1280 {
lab=Di[28]}
N 4930 -1260 4950 -1260 {
lab=Di[29]}
N 4930 -1240 4950 -1240 {
lab=Di[30]}
N 4930 -1220 4950 -1220 {
lab=Di[31]}
N 5020 -1900 5020 -1880 {
lab=CLK_buf}
N 5040 -1900 5040 -1880 {
lab=SEL[20]}
N 5060 -1900 5060 -1880 {
lab=we0_buf}
N 5080 -1900 5080 -1880 {
lab=we1_buf}
N 5100 -1900 5100 -1880 {
lab=we2_buf}
N 5120 -1900 5120 -1880 {
lab=we3_buf}
N 5150 -1900 5150 -1880 {
lab=VDD}
N 5170 -1900 5170 -1880 {
lab=VSS}
N 5450 -1840 5470 -1840 {
lab=di0_buf}
N 5450 -1820 5470 -1820 {
lab=di1_buf}
N 5450 -1800 5470 -1800 {
lab=di2_buf}
N 5450 -1780 5470 -1780 {
lab=di3_buf}
N 5450 -1760 5470 -1760 {
lab=di4_buf}
N 5450 -1740 5470 -1740 {
lab=di5_buf}
N 5450 -1720 5470 -1720 {
lab=di6_buf}
N 5450 -1700 5470 -1700 {
lab=di7_buf}
N 5450 -1680 5470 -1680 {
lab=di8_buf}
N 5450 -1660 5470 -1660 {
lab=di9_buf}
N 5450 -1640 5470 -1640 {
lab=di10_buf}
N 5450 -1620 5470 -1620 {
lab=di11_buf}
N 5450 -1600 5470 -1600 {
lab=di12_buf}
N 5450 -1580 5470 -1580 {
lab=di13_buf}
N 5450 -1560 5470 -1560 {
lab=di14_buf}
N 5450 -1540 5470 -1540 {
lab=di15_buf}
N 5450 -1520 5470 -1520 {
lab=di16_buf}
N 5450 -1500 5470 -1500 {
lab=Di[17]}
N 5450 -1480 5470 -1480 {
lab=Di[18]}
N 5450 -1460 5470 -1460 {
lab=Di[19]}
N 5450 -1440 5470 -1440 {
lab=Di[20]}
N 5450 -1420 5470 -1420 {
lab=Di[21]}
N 5450 -1400 5470 -1400 {
lab=Di[22]}
N 5450 -1380 5470 -1380 {
lab=Di[23]}
N 5450 -1360 5470 -1360 {
lab=Di[24]}
N 5450 -1340 5470 -1340 {
lab=Di[25]}
N 5450 -1320 5470 -1320 {
lab=Di[26]}
N 5450 -1300 5470 -1300 {
lab=Di[27]}
N 5450 -1280 5470 -1280 {
lab=Di[28]}
N 5450 -1260 5470 -1260 {
lab=Di[29]}
N 5450 -1240 5470 -1240 {
lab=Di[30]}
N 5450 -1220 5470 -1220 {
lab=Di[31]}
N 5540 -1900 5540 -1880 {
lab=CLK_buf}
N 5560 -1900 5560 -1880 {
lab=SEL[21]}
N 5580 -1900 5580 -1880 {
lab=we0_buf}
N 5600 -1900 5600 -1880 {
lab=we1_buf}
N 5620 -1900 5620 -1880 {
lab=we2_buf}
N 5640 -1900 5640 -1880 {
lab=we3_buf}
N 5670 -1900 5670 -1880 {
lab=VDD}
N 5690 -1900 5690 -1880 {
lab=VSS}
N 5990 -1840 6010 -1840 {
lab=di0_buf}
N 5990 -1820 6010 -1820 {
lab=di1_buf}
N 5990 -1800 6010 -1800 {
lab=di2_buf}
N 5990 -1780 6010 -1780 {
lab=di3_buf}
N 5990 -1760 6010 -1760 {
lab=di4_buf}
N 5990 -1740 6010 -1740 {
lab=di5_buf}
N 5990 -1720 6010 -1720 {
lab=di6_buf}
N 5990 -1700 6010 -1700 {
lab=di7_buf}
N 5990 -1680 6010 -1680 {
lab=di8_buf}
N 5990 -1660 6010 -1660 {
lab=di9_buf}
N 5990 -1640 6010 -1640 {
lab=di10_buf}
N 5990 -1620 6010 -1620 {
lab=di11_buf}
N 5990 -1600 6010 -1600 {
lab=di12_buf}
N 5990 -1580 6010 -1580 {
lab=di13_buf}
N 5990 -1560 6010 -1560 {
lab=di14_buf}
N 5990 -1540 6010 -1540 {
lab=di15_buf}
N 5990 -1520 6010 -1520 {
lab=di16_buf}
N 5990 -1500 6010 -1500 {
lab=Di[17]}
N 5990 -1480 6010 -1480 {
lab=Di[18]}
N 5990 -1460 6010 -1460 {
lab=Di[19]}
N 5990 -1440 6010 -1440 {
lab=Di[20]}
N 5990 -1420 6010 -1420 {
lab=Di[21]}
N 5990 -1400 6010 -1400 {
lab=Di[22]}
N 5990 -1380 6010 -1380 {
lab=Di[23]}
N 5990 -1360 6010 -1360 {
lab=Di[24]}
N 5990 -1340 6010 -1340 {
lab=Di[25]}
N 5990 -1320 6010 -1320 {
lab=Di[26]}
N 5990 -1300 6010 -1300 {
lab=Di[27]}
N 5990 -1280 6010 -1280 {
lab=Di[28]}
N 5990 -1260 6010 -1260 {
lab=Di[29]}
N 5990 -1240 6010 -1240 {
lab=Di[30]}
N 5990 -1220 6010 -1220 {
lab=Di[31]}
N 6080 -1900 6080 -1880 {
lab=CLK_buf}
N 6100 -1900 6100 -1880 {
lab=SEL[22]}
N 6120 -1900 6120 -1880 {
lab=we0_buf}
N 6140 -1900 6140 -1880 {
lab=we1_buf}
N 6160 -1900 6160 -1880 {
lab=we2_buf}
N 6180 -1900 6180 -1880 {
lab=we3_buf}
N 6210 -1900 6210 -1880 {
lab=VDD}
N 6230 -1900 6230 -1880 {
lab=VSS}
N 6510 -1840 6530 -1840 {
lab=di0_buf}
N 6510 -1820 6530 -1820 {
lab=di1_buf}
N 6510 -1800 6530 -1800 {
lab=di2_buf}
N 6510 -1780 6530 -1780 {
lab=di3_buf}
N 6510 -1760 6530 -1760 {
lab=di4_buf}
N 6510 -1740 6530 -1740 {
lab=di5_buf}
N 6510 -1720 6530 -1720 {
lab=di6_buf}
N 6510 -1700 6530 -1700 {
lab=di7_buf}
N 6510 -1680 6530 -1680 {
lab=di8_buf}
N 6510 -1660 6530 -1660 {
lab=di9_buf}
N 6510 -1640 6530 -1640 {
lab=di10_buf}
N 6510 -1620 6530 -1620 {
lab=di11_buf}
N 6510 -1600 6530 -1600 {
lab=di12_buf}
N 6510 -1580 6530 -1580 {
lab=di13_buf}
N 6510 -1560 6530 -1560 {
lab=di14_buf}
N 6510 -1540 6530 -1540 {
lab=di15_buf}
N 6510 -1520 6530 -1520 {
lab=di16_buf}
N 6510 -1500 6530 -1500 {
lab=Di[17]}
N 6510 -1480 6530 -1480 {
lab=Di[18]}
N 6510 -1460 6530 -1460 {
lab=Di[19]}
N 6510 -1440 6530 -1440 {
lab=Di[20]}
N 6510 -1420 6530 -1420 {
lab=Di[21]}
N 6510 -1400 6530 -1400 {
lab=Di[22]}
N 6510 -1380 6530 -1380 {
lab=Di[23]}
N 6510 -1360 6530 -1360 {
lab=Di[24]}
N 6510 -1340 6530 -1340 {
lab=Di[25]}
N 6510 -1320 6530 -1320 {
lab=Di[26]}
N 6510 -1300 6530 -1300 {
lab=Di[27]}
N 6510 -1280 6530 -1280 {
lab=Di[28]}
N 6510 -1260 6530 -1260 {
lab=Di[29]}
N 6510 -1240 6530 -1240 {
lab=Di[30]}
N 6510 -1220 6530 -1220 {
lab=Di[31]}
N 6600 -1900 6600 -1880 {
lab=CLK_buf}
N 6620 -1900 6620 -1880 {
lab=SEL[23]}
N 6640 -1900 6640 -1880 {
lab=we0_buf}
N 6660 -1900 6660 -1880 {
lab=we1_buf}
N 6680 -1900 6680 -1880 {
lab=we2_buf}
N 6700 -1900 6700 -1880 {
lab=we3_buf}
N 6730 -1900 6730 -1880 {
lab=VDD}
N 6750 -1900 6750 -1880 {
lab=VSS}
N 6510 -940 6530 -940 {
lab=di0_buf}
N 6510 -920 6530 -920 {
lab=di1_buf}
N 6510 -900 6530 -900 {
lab=di2_buf}
N 6510 -880 6530 -880 {
lab=di3_buf}
N 6510 -860 6530 -860 {
lab=di4_buf}
N 6510 -840 6530 -840 {
lab=di5_buf}
N 6510 -820 6530 -820 {
lab=di6_buf}
N 6510 -800 6530 -800 {
lab=di7_buf}
N 6510 -780 6530 -780 {
lab=di8_buf}
N 6510 -760 6530 -760 {
lab=di9_buf}
N 6510 -740 6530 -740 {
lab=di10_buf}
N 6510 -720 6530 -720 {
lab=di11_buf}
N 6510 -700 6530 -700 {
lab=di12_buf}
N 6510 -680 6530 -680 {
lab=di13_buf}
N 6510 -660 6530 -660 {
lab=di14_buf}
N 6510 -640 6530 -640 {
lab=di15_buf}
N 6510 -620 6530 -620 {
lab=di16_buf}
N 6510 -600 6530 -600 {
lab=Di[17]}
N 6510 -580 6530 -580 {
lab=Di[18]}
N 6510 -560 6530 -560 {
lab=Di[19]}
N 6510 -540 6530 -540 {
lab=Di[20]}
N 6510 -520 6530 -520 {
lab=Di[21]}
N 6510 -500 6530 -500 {
lab=Di[22]}
N 6510 -480 6530 -480 {
lab=Di[23]}
N 6510 -460 6530 -460 {
lab=Di[24]}
N 6510 -440 6530 -440 {
lab=Di[25]}
N 6510 -420 6530 -420 {
lab=Di[26]}
N 6510 -400 6530 -400 {
lab=Di[27]}
N 6510 -380 6530 -380 {
lab=Di[28]}
N 6510 -360 6530 -360 {
lab=Di[29]}
N 6510 -340 6530 -340 {
lab=Di[30]}
N 6510 -320 6530 -320 {
lab=Di[31]}
N 6600 -1000 6600 -980 {
lab=CLK_buf}
N 6620 -1000 6620 -980 {
lab=SEL[31]}
N 6640 -1000 6640 -980 {
lab=we0_buf}
N 6660 -1000 6660 -980 {
lab=we1_buf}
N 6680 -1000 6680 -980 {
lab=we2_buf}
N 6700 -1000 6700 -980 {
lab=we3_buf}
N 6730 -1000 6730 -980 {
lab=VDD}
N 6750 -1000 6750 -980 {
lab=VSS}
N 5990 -940 6010 -940 {
lab=di0_buf}
N 5990 -920 6010 -920 {
lab=di1_buf}
N 5990 -900 6010 -900 {
lab=di2_buf}
N 5990 -880 6010 -880 {
lab=di3_buf}
N 5990 -860 6010 -860 {
lab=di4_buf}
N 5990 -840 6010 -840 {
lab=di5_buf}
N 5990 -820 6010 -820 {
lab=di6_buf}
N 5990 -800 6010 -800 {
lab=di7_buf}
N 5990 -780 6010 -780 {
lab=di8_buf}
N 5990 -760 6010 -760 {
lab=di9_buf}
N 5990 -740 6010 -740 {
lab=di10_buf}
N 5990 -720 6010 -720 {
lab=di11_buf}
N 5990 -700 6010 -700 {
lab=di12_buf}
N 5990 -680 6010 -680 {
lab=di13_buf}
N 5990 -660 6010 -660 {
lab=di14_buf}
N 5990 -640 6010 -640 {
lab=di15_buf}
N 5990 -620 6010 -620 {
lab=di16_buf}
N 5990 -600 6010 -600 {
lab=Di[17]}
N 5990 -580 6010 -580 {
lab=Di[18]}
N 5990 -560 6010 -560 {
lab=Di[19]}
N 5990 -540 6010 -540 {
lab=Di[20]}
N 5990 -520 6010 -520 {
lab=Di[21]}
N 5990 -500 6010 -500 {
lab=Di[22]}
N 5990 -480 6010 -480 {
lab=Di[23]}
N 5990 -460 6010 -460 {
lab=Di[24]}
N 5990 -440 6010 -440 {
lab=Di[25]}
N 5990 -420 6010 -420 {
lab=Di[26]}
N 5990 -400 6010 -400 {
lab=Di[27]}
N 5990 -380 6010 -380 {
lab=Di[28]}
N 5990 -360 6010 -360 {
lab=Di[29]}
N 5990 -340 6010 -340 {
lab=Di[30]}
N 5990 -320 6010 -320 {
lab=Di[31]}
N 6080 -1000 6080 -980 {
lab=CLK_buf}
N 6100 -1000 6100 -980 {
lab=SEL[30]}
N 6120 -1000 6120 -980 {
lab=we0_buf}
N 6140 -1000 6140 -980 {
lab=we1_buf}
N 6160 -1000 6160 -980 {
lab=we2_buf}
N 6180 -1000 6180 -980 {
lab=we3_buf}
N 6210 -1000 6210 -980 {
lab=VDD}
N 6230 -1000 6230 -980 {
lab=VSS}
N 5450 -940 5470 -940 {
lab=di0_buf}
N 5450 -920 5470 -920 {
lab=di1_buf}
N 5450 -900 5470 -900 {
lab=di2_buf}
N 5450 -880 5470 -880 {
lab=di3_buf}
N 5450 -860 5470 -860 {
lab=di4_buf}
N 5450 -840 5470 -840 {
lab=di5_buf}
N 5450 -820 5470 -820 {
lab=di6_buf}
N 5450 -800 5470 -800 {
lab=di7_buf}
N 5450 -780 5470 -780 {
lab=di8_buf}
N 5450 -760 5470 -760 {
lab=di9_buf}
N 5450 -740 5470 -740 {
lab=di10_buf}
N 5450 -720 5470 -720 {
lab=di11_buf}
N 5450 -700 5470 -700 {
lab=di12_buf}
N 5450 -680 5470 -680 {
lab=di13_buf}
N 5450 -660 5470 -660 {
lab=di14_buf}
N 5450 -640 5470 -640 {
lab=di15_buf}
N 5450 -620 5470 -620 {
lab=di16_buf}
N 5450 -600 5470 -600 {
lab=Di[17]}
N 5450 -580 5470 -580 {
lab=Di[18]}
N 5450 -560 5470 -560 {
lab=Di[19]}
N 5450 -540 5470 -540 {
lab=Di[20]}
N 5450 -520 5470 -520 {
lab=Di[21]}
N 5450 -500 5470 -500 {
lab=Di[22]}
N 5450 -480 5470 -480 {
lab=Di[23]}
N 5450 -460 5470 -460 {
lab=Di[24]}
N 5450 -440 5470 -440 {
lab=Di[25]}
N 5450 -420 5470 -420 {
lab=Di[26]}
N 5450 -400 5470 -400 {
lab=Di[27]}
N 5450 -380 5470 -380 {
lab=Di[28]}
N 5450 -360 5470 -360 {
lab=Di[29]}
N 5450 -340 5470 -340 {
lab=Di[30]}
N 5450 -320 5470 -320 {
lab=Di[31]}
N 5540 -1000 5540 -980 {
lab=CLK_buf}
N 5560 -1000 5560 -980 {
lab=SEL[29]}
N 5580 -1000 5580 -980 {
lab=we0_buf}
N 5600 -1000 5600 -980 {
lab=we1_buf}
N 5620 -1000 5620 -980 {
lab=we2_buf}
N 5640 -1000 5640 -980 {
lab=we3_buf}
N 5670 -1000 5670 -980 {
lab=VDD}
N 5690 -1000 5690 -980 {
lab=VSS}
N 4930 -940 4950 -940 {
lab=di0_buf}
N 4930 -920 4950 -920 {
lab=di1_buf}
N 4930 -900 4950 -900 {
lab=di2_buf}
N 4930 -880 4950 -880 {
lab=di3_buf}
N 4930 -860 4950 -860 {
lab=di4_buf}
N 4930 -840 4950 -840 {
lab=di5_buf}
N 4930 -820 4950 -820 {
lab=di6_buf}
N 4930 -800 4950 -800 {
lab=di7_buf}
N 4930 -780 4950 -780 {
lab=di8_buf}
N 4930 -760 4950 -760 {
lab=di9_buf}
N 4930 -740 4950 -740 {
lab=di10_buf}
N 4930 -720 4950 -720 {
lab=di11_buf}
N 4930 -700 4950 -700 {
lab=di12_buf}
N 4930 -680 4950 -680 {
lab=di13_buf}
N 4930 -660 4950 -660 {
lab=di14_buf}
N 4930 -640 4950 -640 {
lab=di15_buf}
N 4930 -620 4950 -620 {
lab=di16_buf}
N 4930 -600 4950 -600 {
lab=Di[17]}
N 4930 -580 4950 -580 {
lab=Di[18]}
N 4930 -560 4950 -560 {
lab=Di[19]}
N 4930 -540 4950 -540 {
lab=Di[20]}
N 4930 -520 4950 -520 {
lab=Di[21]}
N 4930 -500 4950 -500 {
lab=Di[22]}
N 4930 -480 4950 -480 {
lab=Di[23]}
N 4930 -460 4950 -460 {
lab=Di[24]}
N 4930 -440 4950 -440 {
lab=Di[25]}
N 4930 -420 4950 -420 {
lab=Di[26]}
N 4930 -400 4950 -400 {
lab=Di[27]}
N 4930 -380 4950 -380 {
lab=Di[28]}
N 4930 -360 4950 -360 {
lab=Di[29]}
N 4930 -340 4950 -340 {
lab=Di[30]}
N 4930 -320 4950 -320 {
lab=Di[31]}
N 5020 -1000 5020 -980 {
lab=CLK_buf}
N 5040 -1000 5040 -980 {
lab=SEL[28]}
N 5060 -1000 5060 -980 {
lab=we0_buf}
N 5080 -1000 5080 -980 {
lab=we1_buf}
N 5100 -1000 5100 -980 {
lab=we2_buf}
N 5120 -1000 5120 -980 {
lab=we3_buf}
N 5150 -1000 5150 -980 {
lab=VDD}
N 5170 -1000 5170 -980 {
lab=VSS}
N 4410 -940 4430 -940 {
lab=di0_buf}
N 4410 -920 4430 -920 {
lab=di1_buf}
N 4410 -900 4430 -900 {
lab=di2_buf}
N 4410 -880 4430 -880 {
lab=di3_buf}
N 4410 -860 4430 -860 {
lab=di4_buf}
N 4410 -840 4430 -840 {
lab=di5_buf}
N 4410 -820 4430 -820 {
lab=di6_buf}
N 4410 -800 4430 -800 {
lab=di7_buf}
N 4410 -780 4430 -780 {
lab=di8_buf}
N 4410 -760 4430 -760 {
lab=di9_buf}
N 4410 -740 4430 -740 {
lab=di10_buf}
N 4410 -720 4430 -720 {
lab=di11_buf}
N 4410 -700 4430 -700 {
lab=di12_buf}
N 4410 -680 4430 -680 {
lab=di13_buf}
N 4410 -660 4430 -660 {
lab=di14_buf}
N 4410 -640 4430 -640 {
lab=di15_buf}
N 4410 -620 4430 -620 {
lab=di16_buf}
N 4410 -600 4430 -600 {
lab=Di[17]}
N 4410 -580 4430 -580 {
lab=Di[18]}
N 4410 -560 4430 -560 {
lab=Di[19]}
N 4410 -540 4430 -540 {
lab=Di[20]}
N 4410 -520 4430 -520 {
lab=Di[21]}
N 4410 -500 4430 -500 {
lab=Di[22]}
N 4410 -480 4430 -480 {
lab=Di[23]}
N 4410 -460 4430 -460 {
lab=Di[24]}
N 4410 -440 4430 -440 {
lab=Di[25]}
N 4410 -420 4430 -420 {
lab=Di[26]}
N 4410 -400 4430 -400 {
lab=Di[27]}
N 4410 -380 4430 -380 {
lab=Di[28]}
N 4410 -360 4430 -360 {
lab=Di[29]}
N 4410 -340 4430 -340 {
lab=Di[30]}
N 4410 -320 4430 -320 {
lab=Di[31]}
N 4500 -1000 4500 -980 {
lab=CLK_buf}
N 4520 -1000 4520 -980 {
lab=SEL[27]}
N 4540 -1000 4540 -980 {
lab=we0_buf}
N 4560 -1000 4560 -980 {
lab=we1_buf}
N 4580 -1000 4580 -980 {
lab=we2_buf}
N 4600 -1000 4600 -980 {
lab=we3_buf}
N 4630 -1000 4630 -980 {
lab=VDD}
N 4650 -1000 4650 -980 {
lab=VSS}
N 3890 -940 3910 -940 {
lab=di0_buf}
N 3890 -920 3910 -920 {
lab=di1_buf}
N 3890 -900 3910 -900 {
lab=di2_buf}
N 3890 -880 3910 -880 {
lab=di3_buf}
N 3890 -860 3910 -860 {
lab=di4_buf}
N 3890 -840 3910 -840 {
lab=di5_buf}
N 3890 -820 3910 -820 {
lab=di6_buf}
N 3890 -800 3910 -800 {
lab=di7_buf}
N 3890 -780 3910 -780 {
lab=di8_buf}
N 3890 -760 3910 -760 {
lab=di9_buf}
N 3890 -740 3910 -740 {
lab=di10_buf}
N 3890 -720 3910 -720 {
lab=di11_buf}
N 3890 -700 3910 -700 {
lab=di12_buf}
N 3890 -680 3910 -680 {
lab=di13_buf}
N 3890 -660 3910 -660 {
lab=di14_buf}
N 3890 -640 3910 -640 {
lab=di15_buf}
N 3890 -620 3910 -620 {
lab=di16_buf}
N 3890 -600 3910 -600 {
lab=Di[17]}
N 3890 -580 3910 -580 {
lab=Di[18]}
N 3890 -560 3910 -560 {
lab=Di[19]}
N 3890 -540 3910 -540 {
lab=Di[20]}
N 3890 -520 3910 -520 {
lab=Di[21]}
N 3890 -500 3910 -500 {
lab=Di[22]}
N 3890 -480 3910 -480 {
lab=Di[23]}
N 3890 -460 3910 -460 {
lab=Di[24]}
N 3890 -440 3910 -440 {
lab=Di[25]}
N 3890 -420 3910 -420 {
lab=Di[26]}
N 3890 -400 3910 -400 {
lab=Di[27]}
N 3890 -380 3910 -380 {
lab=Di[28]}
N 3890 -360 3910 -360 {
lab=Di[29]}
N 3890 -340 3910 -340 {
lab=Di[30]}
N 3890 -320 3910 -320 {
lab=Di[31]}
N 3980 -1000 3980 -980 {
lab=CLK_buf}
N 4000 -1000 4000 -980 {
lab=SEL[26]}
N 4020 -1000 4020 -980 {
lab=we0_buf}
N 4040 -1000 4040 -980 {
lab=we1_buf}
N 4060 -1000 4060 -980 {
lab=we2_buf}
N 4080 -1000 4080 -980 {
lab=we3_buf}
N 4110 -1000 4110 -980 {
lab=VDD}
N 4130 -1000 4130 -980 {
lab=VSS}
N 3350 -940 3370 -940 {
lab=di0_buf}
N 3350 -920 3370 -920 {
lab=di1_buf}
N 3350 -900 3370 -900 {
lab=di2_buf}
N 3350 -880 3370 -880 {
lab=di3_buf}
N 3350 -860 3370 -860 {
lab=di4_buf}
N 3350 -840 3370 -840 {
lab=di5_buf}
N 3350 -820 3370 -820 {
lab=di6_buf}
N 3350 -800 3370 -800 {
lab=di7_buf}
N 3350 -780 3370 -780 {
lab=di8_buf}
N 3350 -760 3370 -760 {
lab=di9_buf}
N 3350 -740 3370 -740 {
lab=di10_buf}
N 3350 -720 3370 -720 {
lab=di11_buf}
N 3350 -700 3370 -700 {
lab=di12_buf}
N 3350 -680 3370 -680 {
lab=di13_buf}
N 3350 -660 3370 -660 {
lab=di14_buf}
N 3350 -640 3370 -640 {
lab=di15_buf}
N 3350 -620 3370 -620 {
lab=di16_buf}
N 3350 -600 3370 -600 {
lab=Di[17]}
N 3350 -580 3370 -580 {
lab=Di[18]}
N 3350 -560 3370 -560 {
lab=Di[19]}
N 3350 -540 3370 -540 {
lab=Di[20]}
N 3350 -520 3370 -520 {
lab=Di[21]}
N 3350 -500 3370 -500 {
lab=Di[22]}
N 3350 -480 3370 -480 {
lab=Di[23]}
N 3350 -460 3370 -460 {
lab=Di[24]}
N 3350 -440 3370 -440 {
lab=Di[25]}
N 3350 -420 3370 -420 {
lab=Di[26]}
N 3350 -400 3370 -400 {
lab=Di[27]}
N 3350 -380 3370 -380 {
lab=Di[28]}
N 3350 -360 3370 -360 {
lab=Di[29]}
N 3350 -340 3370 -340 {
lab=Di[30]}
N 3350 -320 3370 -320 {
lab=Di[31]}
N 3440 -1000 3440 -980 {
lab=CLK_buf}
N 3460 -1000 3460 -980 {
lab=SEL[25]}
N 3480 -1000 3480 -980 {
lab=we0_buf}
N 3500 -1000 3500 -980 {
lab=we1_buf}
N 3520 -1000 3520 -980 {
lab=we2_buf}
N 3540 -1000 3540 -980 {
lab=we3_buf}
N 3570 -1000 3570 -980 {
lab=VDD}
N 3590 -1000 3590 -980 {
lab=VSS}
N 2830 -940 2850 -940 {
lab=di0_buf}
N 2830 -920 2850 -920 {
lab=di1_buf}
N 2830 -900 2850 -900 {
lab=di2_buf}
N 2830 -880 2850 -880 {
lab=di3_buf}
N 2830 -860 2850 -860 {
lab=di4_buf}
N 2830 -840 2850 -840 {
lab=di5_buf}
N 2830 -820 2850 -820 {
lab=di6_buf}
N 2830 -800 2850 -800 {
lab=di7_buf}
N 2830 -780 2850 -780 {
lab=di8_buf}
N 2830 -760 2850 -760 {
lab=di9_buf}
N 2830 -740 2850 -740 {
lab=di10_buf}
N 2830 -720 2850 -720 {
lab=di11_buf}
N 2830 -700 2850 -700 {
lab=di12_buf}
N 2830 -680 2850 -680 {
lab=di13_buf}
N 2830 -660 2850 -660 {
lab=di14_buf}
N 2830 -640 2850 -640 {
lab=di15_buf}
N 2830 -620 2850 -620 {
lab=di16_buf}
N 2830 -600 2850 -600 {
lab=Di[17]}
N 2830 -580 2850 -580 {
lab=Di[18]}
N 2830 -560 2850 -560 {
lab=Di[19]}
N 2830 -540 2850 -540 {
lab=Di[20]}
N 2830 -520 2850 -520 {
lab=Di[21]}
N 2830 -500 2850 -500 {
lab=Di[22]}
N 2830 -480 2850 -480 {
lab=Di[23]}
N 2830 -460 2850 -460 {
lab=Di[24]}
N 2830 -440 2850 -440 {
lab=Di[25]}
N 2830 -420 2850 -420 {
lab=Di[26]}
N 2830 -400 2850 -400 {
lab=Di[27]}
N 2830 -380 2850 -380 {
lab=Di[28]}
N 2830 -360 2850 -360 {
lab=Di[29]}
N 2830 -340 2850 -340 {
lab=Di[30]}
N 2830 -320 2850 -320 {
lab=Di[31]}
N 2920 -1000 2920 -980 {
lab=CLK_buf}
N 2940 -1000 2940 -980 {
lab=SEL[24]}
N 2960 -1000 2960 -980 {
lab=we0_buf}
N 2980 -1000 2980 -980 {
lab=we1_buf}
N 3000 -1000 3000 -980 {
lab=we2_buf}
N 3020 -1000 3020 -980 {
lab=we3_buf}
N 3050 -1000 3050 -980 {
lab=VDD}
N 3070 -1000 3070 -980 {
lab=VSS}
N 1150 -3970 1150 -3960 {
lab=VDD}
N 1150 -3880 1150 -3870 {
lab=VSS}
N 1600 -3920 1620 -3920 {
lab=CLK_buf}
N 1270 -3920 1280 -3920 {
lab=#net37}
N 1340 -3970 1340 -3960 {
lab=VDD}
N 1340 -3880 1340 -3870 {
lab=VSS}
N 1060 -3920 1080 -3920 {
lab=#net38}
N 890 -3920 900 -3920 {
lab=CLK}
N 960 -3970 960 -3960 {
lab=VDD}
N 960 -3880 960 -3870 {
lab=VSS}
N 1620 -3920 1640 -3920 {lab=CLK_buf}
N 1040 -3920 1060 -3920 {
lab=#net38}
N 1450 -3920 1460 -3920 {
lab=#net51}
N 1520 -3970 1520 -3960 {
lab=VDD}
N 1520 -3880 1520 -3870 {
lab=VSS}
N 1420 -3920 1450 -3920 {
lab=#net51}
N 1080 -180 1100 -180 {
lab=Di28}
N 1080 -310 1100 -310 {
lab=Di24}
N 1080 -440 1100 -440 {
lab=Di20}
N 1080 -570 1100 -570 {
lab=Di16}
N 1080 -700 1100 -700 {
lab=Di12}
N 1080 -830 1100 -830 {
lab=Di8}
N 1080 -960 1100 -960 {
lab=Di4}
N 1080 -1090 1100 -1090 {
lab=Di0}
N 1640 -1090 1660 -1090 {
lab=#net52}
N 1560 -1130 1720 -1130 {
lab=VDD}
N 1560 -1050 1720 -1050 {
lab=VSS}
N 1640 -960 1660 -960 {
lab=#net53}
N 1560 -1000 1720 -1000 {
lab=VDD}
N 1560 -920 1720 -920 {
lab=VSS}
N 1640 -830 1660 -830 {
lab=#net54}
N 1560 -870 1720 -870 {
lab=VDD}
N 1560 -790 1720 -790 {
lab=VSS}
N 1640 -700 1660 -700 {
lab=#net55}
N 1560 -740 1720 -740 {
lab=VDD}
N 1560 -660 1720 -660 {
lab=VSS}
N 1640 -570 1660 -570 {
lab=#net56}
N 1560 -610 1720 -610 {
lab=VDD}
N 1560 -530 1720 -530 {
lab=VSS}
N 1640 -440 1660 -440 {
lab=#net57}
N 1560 -480 1720 -480 {
lab=VDD}
N 1560 -400 1720 -400 {
lab=VSS}
N 1640 -310 1660 -310 {
lab=#net58}
N 1560 -350 1720 -350 {
lab=VDD}
N 1560 -270 1720 -270 {
lab=VSS}
N 1640 -180 1660 -180 {
lab=#net59}
N 1560 -220 1720 -220 {
lab=VDD}
N 1560 -140 1720 -140 {
lab=VSS}
N 2040 -1090 2060 -1090 {
lab=#net60}
N 1960 -1130 2120 -1130 {
lab=VDD}
N 1960 -1050 2120 -1050 {
lab=VSS}
N 2040 -960 2060 -960 {
lab=#net61}
N 1960 -1000 2120 -1000 {
lab=VDD}
N 1960 -920 2120 -920 {
lab=VSS}
N 2040 -830 2060 -830 {
lab=#net62}
N 1960 -870 2120 -870 {
lab=VDD}
N 1960 -790 2120 -790 {
lab=VSS}
N 2040 -700 2060 -700 {
lab=#net63}
N 1960 -740 2120 -740 {
lab=VDD}
N 1960 -660 2120 -660 {
lab=VSS}
N 2040 -570 2060 -570 {
lab=#net64}
N 1960 -610 2120 -610 {
lab=VDD}
N 1960 -530 2120 -530 {
lab=VSS}
N 2040 -440 2060 -440 {
lab=#net65}
N 1960 -480 2120 -480 {
lab=VDD}
N 1960 -400 2120 -400 {
lab=VSS}
N 2040 -310 2060 -310 {
lab=#net66}
N 1960 -350 2120 -350 {
lab=VDD}
N 1960 -270 2120 -270 {
lab=VSS}
N 2040 -180 2060 -180 {
lab=#net67}
N 1960 -220 2120 -220 {
lab=VDD}
N 1960 -140 2120 -140 {
lab=VSS}
N 2440 -1090 2460 -1090 {
lab=#net68}
N 2360 -1130 2520 -1130 {
lab=VDD}
N 2360 -1050 2520 -1050 {
lab=VSS}
N 2440 -960 2460 -960 {
lab=#net69}
N 2360 -1000 2520 -1000 {
lab=VDD}
N 2360 -920 2520 -920 {
lab=VSS}
N 2440 -830 2460 -830 {
lab=#net70}
N 2360 -870 2520 -870 {
lab=VDD}
N 2360 -790 2520 -790 {
lab=VSS}
N 2440 -700 2460 -700 {
lab=#net71}
N 2360 -740 2520 -740 {
lab=VDD}
N 2360 -660 2520 -660 {
lab=VSS}
N 2440 -570 2460 -570 {
lab=#net72}
N 2360 -610 2520 -610 {
lab=VDD}
N 2360 -530 2520 -530 {
lab=VSS}
N 2440 -440 2460 -440 {
lab=#net73}
N 2360 -480 2520 -480 {
lab=VDD}
N 2360 -400 2520 -400 {
lab=VSS}
N 2440 -310 2460 -310 {
lab=#net74}
N 2360 -350 2520 -350 {
lab=VDD}
N 2360 -270 2520 -270 {
lab=VSS}
N 2440 -180 2460 -180 {
lab=#net75}
N 2360 -220 2520 -220 {
lab=VDD}
N 2360 -140 2520 -140 {
lab=VSS}
N 1880 -1090 1900 -1090 {
lab=Di2}
N 1880 -960 1900 -960 {
lab=Di6}
N 1880 -830 1900 -830 {
lab=Di10}
N 1880 -700 1900 -700 {
lab=Di14}
N 1880 -570 1900 -570 {
lab=Di18}
N 1880 -440 1900 -440 {
lab=Di22}
N 1880 -310 1900 -310 {
lab=Di26}
N 1880 -180 1900 -180 {
lab=Di30}
N 2280 -1090 2300 -1090 {
lab=Di3}
N 2280 -960 2300 -960 {
lab=Di7}
N 2280 -830 2300 -830 {
lab=Di11}
N 2280 -700 2300 -700 {
lab=Di15}
N 2280 -570 2300 -570 {
lab=Di19}
N 2280 -440 2300 -440 {
lab=Di23}
N 2280 -310 2300 -310 {
lab=Di27}
N 2280 -180 2300 -180 {
lab=Di31}
N 1480 -1090 1500 -1090 {
lab=Di1}
N 1480 -960 1500 -960 {
lab=Di5}
N 1480 -830 1500 -830 {
lab=Di9}
N 1480 -700 1500 -700 {
lab=Di13}
N 1480 -570 1500 -570 {
lab=Di17}
N 1480 -440 1500 -440 {
lab=Di21}
N 1480 -310 1500 -310 {
lab=Di25}
N 1480 -180 1500 -180 {
lab=Di29}
N 3660 -3690 3680 -3690 {
lab=Do0}
N 3660 -3670 3680 -3670 {
lab=Do1}
N 3660 -3650 3680 -3650 {
lab=Do2}
N 3660 -3630 3680 -3630 {
lab=Do3}
N 3660 -3610 3680 -3610 {
lab=Do4}
N 3660 -3590 3680 -3590 {
lab=Do5}
N 3660 -3570 3680 -3570 {
lab=Do6}
N 3660 -3550 3680 -3550 {
lab=Do7}
N 3660 -3530 3680 -3530 {
lab=Do8}
N 3660 -3510 3680 -3510 {
lab=Do9}
N 3660 -3490 3680 -3490 {
lab=Do10}
N 3660 -3470 3680 -3470 {
lab=Do11}
N 3660 -3450 3680 -3450 {
lab=Do12}
N 3660 -3430 3680 -3430 {
lab=Do13}
N 3660 -3410 3680 -3410 {
lab=Do14}
N 3660 -3390 3680 -3390 {
lab=Do15}
N 3660 -3370 3680 -3370 {
lab=Do16}
N 3660 -3350 3680 -3350 {
lab=Do17}
N 3660 -3330 3680 -3330 {
lab=Do18}
N 3660 -3310 3680 -3310 {
lab=Do19}
N 3660 -3290 3680 -3290 {
lab=Do20}
N 3660 -3270 3680 -3270 {
lab=Do21}
N 3660 -3250 3680 -3250 {
lab=Do22}
N 3660 -3230 3680 -3230 {
lab=Do23}
N 3660 -3210 3680 -3210 {
lab=Do24}
N 3660 -3190 3680 -3190 {
lab=Do25}
N 3660 -3170 3680 -3170 {
lab=Do26}
N 3660 -3150 3680 -3150 {
lab=Do27}
N 3660 -3130 3680 -3130 {
lab=Do28}
N 3660 -3110 3680 -3110 {
lab=Do29}
N 3660 -3090 3680 -3090 {
lab=Do30}
N 3660 -3070 3680 -3070 {
lab=Do31}
N 4200 -3690 4220 -3690 {
lab=Do0}
N 4200 -3670 4220 -3670 {
lab=Do1}
N 4200 -3650 4220 -3650 {
lab=Do2}
N 4200 -3630 4220 -3630 {
lab=Do3}
N 4200 -3610 4220 -3610 {
lab=Do4}
N 4200 -3590 4220 -3590 {
lab=Do5}
N 4200 -3570 4220 -3570 {
lab=Do6}
N 4200 -3550 4220 -3550 {
lab=Do7}
N 4200 -3530 4220 -3530 {
lab=Do8}
N 4200 -3510 4220 -3510 {
lab=Do9}
N 4200 -3490 4220 -3490 {
lab=Do10}
N 4200 -3470 4220 -3470 {
lab=Do11}
N 4200 -3450 4220 -3450 {
lab=Do12}
N 4200 -3430 4220 -3430 {
lab=Do13}
N 4200 -3410 4220 -3410 {
lab=Do14}
N 4200 -3390 4220 -3390 {
lab=Do15}
N 4200 -3370 4220 -3370 {
lab=Do16}
N 4200 -3350 4220 -3350 {
lab=Do17}
N 4200 -3330 4220 -3330 {
lab=Do18}
N 4200 -3310 4220 -3310 {
lab=Do19}
N 4200 -3290 4220 -3290 {
lab=Do20}
N 4200 -3270 4220 -3270 {
lab=Do21}
N 4200 -3250 4220 -3250 {
lab=Do22}
N 4200 -3230 4220 -3230 {
lab=Do23}
N 4200 -3210 4220 -3210 {
lab=Do24}
N 4200 -3190 4220 -3190 {
lab=Do25}
N 4200 -3170 4220 -3170 {
lab=Do26}
N 4200 -3150 4220 -3150 {
lab=Do27}
N 4200 -3130 4220 -3130 {
lab=Do28}
N 4200 -3110 4220 -3110 {
lab=Do29}
N 4200 -3090 4220 -3090 {
lab=Do30}
N 4200 -3070 4220 -3070 {
lab=Do31}
N 4720 -3690 4740 -3690 {
lab=Do0}
N 4720 -3670 4740 -3670 {
lab=Do1}
N 4720 -3650 4740 -3650 {
lab=Do2}
N 4720 -3630 4740 -3630 {
lab=Do3}
N 4720 -3610 4740 -3610 {
lab=Do4}
N 4720 -3590 4740 -3590 {
lab=Do5}
N 4720 -3570 4740 -3570 {
lab=Do6}
N 4720 -3550 4740 -3550 {
lab=Do7}
N 4720 -3530 4740 -3530 {
lab=Do8}
N 4720 -3510 4740 -3510 {
lab=Do9}
N 4720 -3490 4740 -3490 {
lab=Do10}
N 4720 -3470 4740 -3470 {
lab=Do11}
N 4720 -3450 4740 -3450 {
lab=Do12}
N 4720 -3430 4740 -3430 {
lab=Do13}
N 4720 -3410 4740 -3410 {
lab=Do14}
N 4720 -3390 4740 -3390 {
lab=Do15}
N 4720 -3370 4740 -3370 {
lab=Do16}
N 4720 -3350 4740 -3350 {
lab=Do17}
N 4720 -3330 4740 -3330 {
lab=Do18}
N 4720 -3310 4740 -3310 {
lab=Do19}
N 4720 -3290 4740 -3290 {
lab=Do20}
N 4720 -3270 4740 -3270 {
lab=Do21}
N 4720 -3250 4740 -3250 {
lab=Do22}
N 4720 -3230 4740 -3230 {
lab=Do23}
N 4720 -3210 4740 -3210 {
lab=Do24}
N 4720 -3190 4740 -3190 {
lab=Do25}
N 4720 -3170 4740 -3170 {
lab=Do26}
N 4720 -3150 4740 -3150 {
lab=Do27}
N 4720 -3130 4740 -3130 {
lab=Do28}
N 4720 -3110 4740 -3110 {
lab=Do29}
N 4720 -3090 4740 -3090 {
lab=Do30}
N 4720 -3070 4740 -3070 {
lab=Do31}
N 5240 -3690 5260 -3690 {
lab=Do0}
N 5240 -3670 5260 -3670 {
lab=Do1}
N 5240 -3650 5260 -3650 {
lab=Do2}
N 5240 -3630 5260 -3630 {
lab=Do3}
N 5240 -3610 5260 -3610 {
lab=Do4}
N 5240 -3590 5260 -3590 {
lab=Do5}
N 5240 -3570 5260 -3570 {
lab=Do6}
N 5240 -3550 5260 -3550 {
lab=Do7}
N 5240 -3530 5260 -3530 {
lab=Do8}
N 5240 -3510 5260 -3510 {
lab=Do9}
N 5240 -3490 5260 -3490 {
lab=Do10}
N 5240 -3470 5260 -3470 {
lab=Do11}
N 5240 -3450 5260 -3450 {
lab=Do12}
N 5240 -3430 5260 -3430 {
lab=Do13}
N 5240 -3410 5260 -3410 {
lab=Do14}
N 5240 -3390 5260 -3390 {
lab=Do15}
N 5240 -3370 5260 -3370 {
lab=Do16}
N 5240 -3350 5260 -3350 {
lab=Do17}
N 5240 -3330 5260 -3330 {
lab=Do18}
N 5240 -3310 5260 -3310 {
lab=Do19}
N 5240 -3290 5260 -3290 {
lab=Do20}
N 5240 -3270 5260 -3270 {
lab=Do21}
N 5240 -3250 5260 -3250 {
lab=Do22}
N 5240 -3230 5260 -3230 {
lab=Do23}
N 5240 -3210 5260 -3210 {
lab=Do24}
N 5240 -3190 5260 -3190 {
lab=Do25}
N 5240 -3170 5260 -3170 {
lab=Do26}
N 5240 -3150 5260 -3150 {
lab=Do27}
N 5240 -3130 5260 -3130 {
lab=Do28}
N 5240 -3110 5260 -3110 {
lab=Do29}
N 5240 -3090 5260 -3090 {
lab=Do30}
N 5240 -3070 5260 -3070 {
lab=Do31}
N 5760 -3690 5780 -3690 {
lab=Do0}
N 5760 -3670 5780 -3670 {
lab=Do1}
N 5760 -3650 5780 -3650 {
lab=Do2}
N 5760 -3630 5780 -3630 {
lab=Do3}
N 5760 -3610 5780 -3610 {
lab=Do4}
N 5760 -3590 5780 -3590 {
lab=Do5}
N 5760 -3570 5780 -3570 {
lab=Do6}
N 5760 -3550 5780 -3550 {
lab=Do7}
N 5760 -3530 5780 -3530 {
lab=Do8}
N 5760 -3510 5780 -3510 {
lab=Do9}
N 5760 -3490 5780 -3490 {
lab=Do10}
N 5760 -3470 5780 -3470 {
lab=Do11}
N 5760 -3450 5780 -3450 {
lab=Do12}
N 5760 -3430 5780 -3430 {
lab=Do13}
N 5760 -3410 5780 -3410 {
lab=Do14}
N 5760 -3390 5780 -3390 {
lab=Do15}
N 5760 -3370 5780 -3370 {
lab=Do16}
N 5760 -3350 5780 -3350 {
lab=Do17}
N 5760 -3330 5780 -3330 {
lab=Do18}
N 5760 -3310 5780 -3310 {
lab=Do19}
N 5760 -3290 5780 -3290 {
lab=Do20}
N 5760 -3270 5780 -3270 {
lab=Do21}
N 5760 -3250 5780 -3250 {
lab=Do22}
N 5760 -3230 5780 -3230 {
lab=Do23}
N 5760 -3210 5780 -3210 {
lab=Do24}
N 5760 -3190 5780 -3190 {
lab=Do25}
N 5760 -3170 5780 -3170 {
lab=Do26}
N 5760 -3150 5780 -3150 {
lab=Do27}
N 5760 -3130 5780 -3130 {
lab=Do28}
N 5760 -3110 5780 -3110 {
lab=Do29}
N 5760 -3090 5780 -3090 {
lab=Do30}
N 5760 -3070 5780 -3070 {
lab=Do31}
N 6300 -3690 6320 -3690 {
lab=Do0}
N 6300 -3670 6320 -3670 {
lab=Do1}
N 6300 -3650 6320 -3650 {
lab=Do2}
N 6300 -3630 6320 -3630 {
lab=Do3}
N 6300 -3610 6320 -3610 {
lab=Do4}
N 6300 -3590 6320 -3590 {
lab=Do5}
N 6300 -3570 6320 -3570 {
lab=Do6}
N 6300 -3550 6320 -3550 {
lab=Do7}
N 6300 -3530 6320 -3530 {
lab=Do8}
N 6300 -3510 6320 -3510 {
lab=Do9}
N 6300 -3490 6320 -3490 {
lab=Do10}
N 6300 -3470 6320 -3470 {
lab=Do11}
N 6300 -3450 6320 -3450 {
lab=Do12}
N 6300 -3430 6320 -3430 {
lab=Do13}
N 6300 -3410 6320 -3410 {
lab=Do14}
N 6300 -3390 6320 -3390 {
lab=Do15}
N 6300 -3370 6320 -3370 {
lab=Do16}
N 6300 -3350 6320 -3350 {
lab=Do17}
N 6300 -3330 6320 -3330 {
lab=Do18}
N 6300 -3310 6320 -3310 {
lab=Do19}
N 6300 -3290 6320 -3290 {
lab=Do20}
N 6300 -3270 6320 -3270 {
lab=Do21}
N 6300 -3250 6320 -3250 {
lab=Do22}
N 6300 -3230 6320 -3230 {
lab=Do23}
N 6300 -3210 6320 -3210 {
lab=Do24}
N 6300 -3190 6320 -3190 {
lab=Do25}
N 6300 -3170 6320 -3170 {
lab=Do26}
N 6300 -3150 6320 -3150 {
lab=Do27}
N 6300 -3130 6320 -3130 {
lab=Do28}
N 6300 -3110 6320 -3110 {
lab=Do29}
N 6300 -3090 6320 -3090 {
lab=Do30}
N 6300 -3070 6320 -3070 {
lab=Do31}
N 6820 -3690 6840 -3690 {
lab=Do0}
N 6820 -3670 6840 -3670 {
lab=Do1}
N 6820 -3650 6840 -3650 {
lab=Do2}
N 6820 -3630 6840 -3630 {
lab=Do3}
N 6820 -3610 6840 -3610 {
lab=Do4}
N 6820 -3590 6840 -3590 {
lab=Do5}
N 6820 -3570 6840 -3570 {
lab=Do6}
N 6820 -3550 6840 -3550 {
lab=Do7}
N 6820 -3530 6840 -3530 {
lab=Do8}
N 6820 -3510 6840 -3510 {
lab=Do9}
N 6820 -3490 6840 -3490 {
lab=Do10}
N 6820 -3470 6840 -3470 {
lab=Do11}
N 6820 -3450 6840 -3450 {
lab=Do12}
N 6820 -3430 6840 -3430 {
lab=Do13}
N 6820 -3410 6840 -3410 {
lab=Do14}
N 6820 -3390 6840 -3390 {
lab=Do15}
N 6820 -3370 6840 -3370 {
lab=Do16}
N 6820 -3350 6840 -3350 {
lab=Do17}
N 6820 -3330 6840 -3330 {
lab=Do18}
N 6820 -3310 6840 -3310 {
lab=Do19}
N 6820 -3290 6840 -3290 {
lab=Do20}
N 6820 -3270 6840 -3270 {
lab=Do21}
N 6820 -3250 6840 -3250 {
lab=Do22}
N 6820 -3230 6840 -3230 {
lab=Do23}
N 6820 -3210 6840 -3210 {
lab=Do24}
N 6820 -3190 6840 -3190 {
lab=Do25}
N 6820 -3170 6840 -3170 {
lab=Do26}
N 6820 -3150 6840 -3150 {
lab=Do27}
N 6820 -3130 6840 -3130 {
lab=Do28}
N 6820 -3110 6840 -3110 {
lab=Do29}
N 6820 -3090 6840 -3090 {
lab=Do30}
N 6820 -3070 6840 -3070 {
lab=Do31}
N 3140 -2790 3160 -2790 {
lab=Do0}
N 3140 -2770 3160 -2770 {
lab=Do1}
N 3140 -2750 3160 -2750 {
lab=Do2}
N 3140 -2730 3160 -2730 {
lab=Do3}
N 3140 -2710 3160 -2710 {
lab=Do4}
N 3140 -2690 3160 -2690 {
lab=Do5}
N 3140 -2670 3160 -2670 {
lab=Do6}
N 3140 -2650 3160 -2650 {
lab=Do7}
N 3140 -2630 3160 -2630 {
lab=Do8}
N 3140 -2610 3160 -2610 {
lab=Do9}
N 3140 -2590 3160 -2590 {
lab=Do10}
N 3140 -2570 3160 -2570 {
lab=Do11}
N 3140 -2550 3160 -2550 {
lab=Do12}
N 3140 -2530 3160 -2530 {
lab=Do13}
N 3140 -2510 3160 -2510 {
lab=Do14}
N 3140 -2490 3160 -2490 {
lab=Do15}
N 3140 -2470 3160 -2470 {
lab=Do16}
N 3140 -2450 3160 -2450 {
lab=Do17}
N 3140 -2430 3160 -2430 {
lab=Do18}
N 3140 -2410 3160 -2410 {
lab=Do19}
N 3140 -2390 3160 -2390 {
lab=Do20}
N 3140 -2370 3160 -2370 {
lab=Do21}
N 3140 -2350 3160 -2350 {
lab=Do22}
N 3140 -2330 3160 -2330 {
lab=Do23}
N 3140 -2310 3160 -2310 {
lab=Do24}
N 3140 -2290 3160 -2290 {
lab=Do25}
N 3140 -2270 3160 -2270 {
lab=Do26}
N 3140 -2250 3160 -2250 {
lab=Do27}
N 3140 -2230 3160 -2230 {
lab=Do28}
N 3140 -2210 3160 -2210 {
lab=Do29}
N 3140 -2190 3160 -2190 {
lab=Do30}
N 3140 -2170 3160 -2170 {
lab=Do31}
N 3150 -1840 3170 -1840 {
lab=Do0}
N 3150 -1820 3170 -1820 {
lab=Do1}
N 3150 -1800 3170 -1800 {
lab=Do2}
N 3150 -1780 3170 -1780 {
lab=Do3}
N 3150 -1760 3170 -1760 {
lab=Do4}
N 3150 -1740 3170 -1740 {
lab=Do5}
N 3150 -1720 3170 -1720 {
lab=Do6}
N 3150 -1700 3170 -1700 {
lab=Do7}
N 3150 -1680 3170 -1680 {
lab=Do8}
N 3150 -1660 3170 -1660 {
lab=Do9}
N 3150 -1640 3170 -1640 {
lab=Do10}
N 3150 -1620 3170 -1620 {
lab=Do11}
N 3150 -1600 3170 -1600 {
lab=Do12}
N 3150 -1580 3170 -1580 {
lab=Do13}
N 3150 -1560 3170 -1560 {
lab=Do14}
N 3150 -1540 3170 -1540 {
lab=Do15}
N 3150 -1520 3170 -1520 {
lab=Do16}
N 3150 -1500 3170 -1500 {
lab=Do17}
N 3150 -1480 3170 -1480 {
lab=Do18}
N 3150 -1460 3170 -1460 {
lab=Do19}
N 3150 -1440 3170 -1440 {
lab=Do20}
N 3150 -1420 3170 -1420 {
lab=Do21}
N 3150 -1400 3170 -1400 {
lab=Do22}
N 3150 -1380 3170 -1380 {
lab=Do23}
N 3150 -1360 3170 -1360 {
lab=Do24}
N 3150 -1340 3170 -1340 {
lab=Do25}
N 3150 -1320 3170 -1320 {
lab=Do26}
N 3150 -1300 3170 -1300 {
lab=Do27}
N 3150 -1280 3170 -1280 {
lab=Do28}
N 3150 -1260 3170 -1260 {
lab=Do29}
N 3150 -1240 3170 -1240 {
lab=Do30}
N 3150 -1220 3170 -1220 {
lab=Do31}
N 3150 -940 3170 -940 {
lab=Do0}
N 3150 -920 3170 -920 {
lab=Do1}
N 3150 -900 3170 -900 {
lab=Do2}
N 3150 -880 3170 -880 {
lab=Do3}
N 3150 -860 3170 -860 {
lab=Do4}
N 3150 -840 3170 -840 {
lab=Do5}
N 3150 -820 3170 -820 {
lab=Do6}
N 3150 -800 3170 -800 {
lab=Do7}
N 3150 -780 3170 -780 {
lab=Do8}
N 3150 -760 3170 -760 {
lab=Do9}
N 3150 -740 3170 -740 {
lab=Do10}
N 3150 -720 3170 -720 {
lab=Do11}
N 3150 -700 3170 -700 {
lab=Do12}
N 3150 -680 3170 -680 {
lab=Do13}
N 3150 -660 3170 -660 {
lab=Do14}
N 3150 -640 3170 -640 {
lab=Do15}
N 3150 -620 3170 -620 {
lab=Do16}
N 3150 -600 3170 -600 {
lab=Do17}
N 3150 -580 3170 -580 {
lab=Do18}
N 3150 -560 3170 -560 {
lab=Do19}
N 3150 -540 3170 -540 {
lab=Do20}
N 3150 -520 3170 -520 {
lab=Do21}
N 3150 -500 3170 -500 {
lab=Do22}
N 3150 -480 3170 -480 {
lab=Do23}
N 3150 -460 3170 -460 {
lab=Do24}
N 3150 -440 3170 -440 {
lab=Do25}
N 3150 -420 3170 -420 {
lab=Do26}
N 3150 -400 3170 -400 {
lab=Do27}
N 3150 -380 3170 -380 {
lab=Do28}
N 3150 -360 3170 -360 {
lab=Do29}
N 3150 -340 3170 -340 {
lab=Do30}
N 3150 -320 3170 -320 {
lab=Do31}
N 3660 -2790 3680 -2790 {
lab=Do0}
N 3660 -2770 3680 -2770 {
lab=Do1}
N 3660 -2750 3680 -2750 {
lab=Do2}
N 3660 -2730 3680 -2730 {
lab=Do3}
N 3660 -2710 3680 -2710 {
lab=Do4}
N 3660 -2690 3680 -2690 {
lab=Do5}
N 3660 -2670 3680 -2670 {
lab=Do6}
N 3660 -2650 3680 -2650 {
lab=Do7}
N 3660 -2630 3680 -2630 {
lab=Do8}
N 3660 -2610 3680 -2610 {
lab=Do9}
N 3660 -2590 3680 -2590 {
lab=Do10}
N 3660 -2570 3680 -2570 {
lab=Do11}
N 3660 -2550 3680 -2550 {
lab=Do12}
N 3660 -2530 3680 -2530 {
lab=Do13}
N 3660 -2510 3680 -2510 {
lab=Do14}
N 3660 -2490 3680 -2490 {
lab=Do15}
N 3660 -2470 3680 -2470 {
lab=Do16}
N 3660 -2450 3680 -2450 {
lab=Do17}
N 3660 -2430 3680 -2430 {
lab=Do18}
N 3660 -2410 3680 -2410 {
lab=Do19}
N 3660 -2390 3680 -2390 {
lab=Do20}
N 3660 -2370 3680 -2370 {
lab=Do21}
N 3660 -2350 3680 -2350 {
lab=Do22}
N 3660 -2330 3680 -2330 {
lab=Do23}
N 3660 -2310 3680 -2310 {
lab=Do24}
N 3660 -2290 3680 -2290 {
lab=Do25}
N 3660 -2270 3680 -2270 {
lab=Do26}
N 3660 -2250 3680 -2250 {
lab=Do27}
N 3660 -2230 3680 -2230 {
lab=Do28}
N 3660 -2210 3680 -2210 {
lab=Do29}
N 3660 -2190 3680 -2190 {
lab=Do30}
N 3660 -2170 3680 -2170 {
lab=Do31}
N 3670 -1840 3690 -1840 {
lab=Do0}
N 3670 -1820 3690 -1820 {
lab=Do1}
N 3670 -1800 3690 -1800 {
lab=Do2}
N 3670 -1780 3690 -1780 {
lab=Do3}
N 3670 -1760 3690 -1760 {
lab=Do4}
N 3670 -1740 3690 -1740 {
lab=Do5}
N 3670 -1720 3690 -1720 {
lab=Do6}
N 3670 -1700 3690 -1700 {
lab=Do7}
N 3670 -1680 3690 -1680 {
lab=Do8}
N 3670 -1660 3690 -1660 {
lab=Do9}
N 3670 -1640 3690 -1640 {
lab=Do10}
N 3670 -1620 3690 -1620 {
lab=Do11}
N 3670 -1600 3690 -1600 {
lab=Do12}
N 3670 -1580 3690 -1580 {
lab=Do13}
N 3670 -1560 3690 -1560 {
lab=Do14}
N 3670 -1540 3690 -1540 {
lab=Do15}
N 3670 -1520 3690 -1520 {
lab=Do16}
N 3670 -1500 3690 -1500 {
lab=Do17}
N 3670 -1480 3690 -1480 {
lab=Do18}
N 3670 -1460 3690 -1460 {
lab=Do19}
N 3670 -1440 3690 -1440 {
lab=Do20}
N 3670 -1420 3690 -1420 {
lab=Do21}
N 3670 -1400 3690 -1400 {
lab=Do22}
N 3670 -1380 3690 -1380 {
lab=Do23}
N 3670 -1360 3690 -1360 {
lab=Do24}
N 3670 -1340 3690 -1340 {
lab=Do25}
N 3670 -1320 3690 -1320 {
lab=Do26}
N 3670 -1300 3690 -1300 {
lab=Do27}
N 3670 -1280 3690 -1280 {
lab=Do28}
N 3670 -1260 3690 -1260 {
lab=Do29}
N 3670 -1240 3690 -1240 {
lab=Do30}
N 3670 -1220 3690 -1220 {
lab=Do31}
N 3670 -940 3690 -940 {
lab=Do0}
N 3670 -920 3690 -920 {
lab=Do1}
N 3670 -900 3690 -900 {
lab=Do2}
N 3670 -880 3690 -880 {
lab=Do3}
N 3670 -860 3690 -860 {
lab=Do4}
N 3670 -840 3690 -840 {
lab=Do5}
N 3670 -820 3690 -820 {
lab=Do6}
N 3670 -800 3690 -800 {
lab=Do7}
N 3670 -780 3690 -780 {
lab=Do8}
N 3670 -760 3690 -760 {
lab=Do9}
N 3670 -740 3690 -740 {
lab=Do10}
N 3670 -720 3690 -720 {
lab=Do11}
N 3670 -700 3690 -700 {
lab=Do12}
N 3670 -680 3690 -680 {
lab=Do13}
N 3670 -660 3690 -660 {
lab=Do14}
N 3670 -640 3690 -640 {
lab=Do15}
N 3670 -620 3690 -620 {
lab=Do16}
N 3670 -600 3690 -600 {
lab=Do17}
N 3670 -580 3690 -580 {
lab=Do18}
N 3670 -560 3690 -560 {
lab=Do19}
N 3670 -540 3690 -540 {
lab=Do20}
N 3670 -520 3690 -520 {
lab=Do21}
N 3670 -500 3690 -500 {
lab=Do22}
N 3670 -480 3690 -480 {
lab=Do23}
N 3670 -460 3690 -460 {
lab=Do24}
N 3670 -440 3690 -440 {
lab=Do25}
N 3670 -420 3690 -420 {
lab=Do26}
N 3670 -400 3690 -400 {
lab=Do27}
N 3670 -380 3690 -380 {
lab=Do28}
N 3670 -360 3690 -360 {
lab=Do29}
N 3670 -340 3690 -340 {
lab=Do30}
N 3670 -320 3690 -320 {
lab=Do31}
N 4200 -2790 4220 -2790 {
lab=Do0}
N 4200 -2770 4220 -2770 {
lab=Do1}
N 4200 -2750 4220 -2750 {
lab=Do2}
N 4200 -2730 4220 -2730 {
lab=Do3}
N 4200 -2710 4220 -2710 {
lab=Do4}
N 4200 -2690 4220 -2690 {
lab=Do5}
N 4200 -2670 4220 -2670 {
lab=Do6}
N 4200 -2650 4220 -2650 {
lab=Do7}
N 4200 -2630 4220 -2630 {
lab=Do8}
N 4200 -2610 4220 -2610 {
lab=Do9}
N 4200 -2590 4220 -2590 {
lab=Do10}
N 4200 -2570 4220 -2570 {
lab=Do11}
N 4200 -2550 4220 -2550 {
lab=Do12}
N 4200 -2530 4220 -2530 {
lab=Do13}
N 4200 -2510 4220 -2510 {
lab=Do14}
N 4200 -2490 4220 -2490 {
lab=Do15}
N 4200 -2470 4220 -2470 {
lab=Do16}
N 4200 -2450 4220 -2450 {
lab=Do17}
N 4200 -2430 4220 -2430 {
lab=Do18}
N 4200 -2410 4220 -2410 {
lab=Do19}
N 4200 -2390 4220 -2390 {
lab=Do20}
N 4200 -2370 4220 -2370 {
lab=Do21}
N 4200 -2350 4220 -2350 {
lab=Do22}
N 4200 -2330 4220 -2330 {
lab=Do23}
N 4200 -2310 4220 -2310 {
lab=Do24}
N 4200 -2290 4220 -2290 {
lab=Do25}
N 4200 -2270 4220 -2270 {
lab=Do26}
N 4200 -2250 4220 -2250 {
lab=Do27}
N 4200 -2230 4220 -2230 {
lab=Do28}
N 4200 -2210 4220 -2210 {
lab=Do29}
N 4200 -2190 4220 -2190 {
lab=Do30}
N 4200 -2170 4220 -2170 {
lab=Do31}
N 4210 -1840 4230 -1840 {
lab=Do0}
N 4210 -1820 4230 -1820 {
lab=Do1}
N 4210 -1800 4230 -1800 {
lab=Do2}
N 4210 -1780 4230 -1780 {
lab=Do3}
N 4210 -1760 4230 -1760 {
lab=Do4}
N 4210 -1740 4230 -1740 {
lab=Do5}
N 4210 -1720 4230 -1720 {
lab=Do6}
N 4210 -1700 4230 -1700 {
lab=Do7}
N 4210 -1680 4230 -1680 {
lab=Do8}
N 4210 -1660 4230 -1660 {
lab=Do9}
N 4210 -1640 4230 -1640 {
lab=Do10}
N 4210 -1620 4230 -1620 {
lab=Do11}
N 4210 -1600 4230 -1600 {
lab=Do12}
N 4210 -1580 4230 -1580 {
lab=Do13}
N 4210 -1560 4230 -1560 {
lab=Do14}
N 4210 -1540 4230 -1540 {
lab=Do15}
N 4210 -1520 4230 -1520 {
lab=Do16}
N 4210 -1500 4230 -1500 {
lab=Do17}
N 4210 -1480 4230 -1480 {
lab=Do18}
N 4210 -1460 4230 -1460 {
lab=Do19}
N 4210 -1440 4230 -1440 {
lab=Do20}
N 4210 -1420 4230 -1420 {
lab=Do21}
N 4210 -1400 4230 -1400 {
lab=Do22}
N 4210 -1380 4230 -1380 {
lab=Do23}
N 4210 -1360 4230 -1360 {
lab=Do24}
N 4210 -1340 4230 -1340 {
lab=Do25}
N 4210 -1320 4230 -1320 {
lab=Do26}
N 4210 -1300 4230 -1300 {
lab=Do27}
N 4210 -1280 4230 -1280 {
lab=Do28}
N 4210 -1260 4230 -1260 {
lab=Do29}
N 4210 -1240 4230 -1240 {
lab=Do30}
N 4210 -1220 4230 -1220 {
lab=Do31}
N 4210 -940 4230 -940 {
lab=Do0}
N 4210 -920 4230 -920 {
lab=Do1}
N 4210 -900 4230 -900 {
lab=Do2}
N 4210 -880 4230 -880 {
lab=Do3}
N 4210 -860 4230 -860 {
lab=Do4}
N 4210 -840 4230 -840 {
lab=Do5}
N 4210 -820 4230 -820 {
lab=Do6}
N 4210 -800 4230 -800 {
lab=Do7}
N 4210 -780 4230 -780 {
lab=Do8}
N 4210 -760 4230 -760 {
lab=Do9}
N 4210 -740 4230 -740 {
lab=Do10}
N 4210 -720 4230 -720 {
lab=Do11}
N 4210 -700 4230 -700 {
lab=Do12}
N 4210 -680 4230 -680 {
lab=Do13}
N 4210 -660 4230 -660 {
lab=Do14}
N 4210 -640 4230 -640 {
lab=Do15}
N 4210 -620 4230 -620 {
lab=Do16}
N 4210 -600 4230 -600 {
lab=Do17}
N 4210 -580 4230 -580 {
lab=Do18}
N 4210 -560 4230 -560 {
lab=Do19}
N 4210 -540 4230 -540 {
lab=Do20}
N 4210 -520 4230 -520 {
lab=Do21}
N 4210 -500 4230 -500 {
lab=Do22}
N 4210 -480 4230 -480 {
lab=Do23}
N 4210 -460 4230 -460 {
lab=Do24}
N 4210 -440 4230 -440 {
lab=Do25}
N 4210 -420 4230 -420 {
lab=Do26}
N 4210 -400 4230 -400 {
lab=Do27}
N 4210 -380 4230 -380 {
lab=Do28}
N 4210 -360 4230 -360 {
lab=Do29}
N 4210 -340 4230 -340 {
lab=Do30}
N 4210 -320 4230 -320 {
lab=Do31}
N 4720 -2790 4740 -2790 {
lab=Do0}
N 4720 -2770 4740 -2770 {
lab=Do1}
N 4720 -2750 4740 -2750 {
lab=Do2}
N 4720 -2730 4740 -2730 {
lab=Do3}
N 4720 -2710 4740 -2710 {
lab=Do4}
N 4720 -2690 4740 -2690 {
lab=Do5}
N 4720 -2670 4740 -2670 {
lab=Do6}
N 4720 -2650 4740 -2650 {
lab=Do7}
N 4720 -2630 4740 -2630 {
lab=Do8}
N 4720 -2610 4740 -2610 {
lab=Do9}
N 4720 -2590 4740 -2590 {
lab=Do10}
N 4720 -2570 4740 -2570 {
lab=Do11}
N 4720 -2550 4740 -2550 {
lab=Do12}
N 4720 -2530 4740 -2530 {
lab=Do13}
N 4720 -2510 4740 -2510 {
lab=Do14}
N 4720 -2490 4740 -2490 {
lab=Do15}
N 4720 -2470 4740 -2470 {
lab=Do16}
N 4720 -2450 4740 -2450 {
lab=Do17}
N 4720 -2430 4740 -2430 {
lab=Do18}
N 4720 -2410 4740 -2410 {
lab=Do19}
N 4720 -2390 4740 -2390 {
lab=Do20}
N 4720 -2370 4740 -2370 {
lab=Do21}
N 4720 -2350 4740 -2350 {
lab=Do22}
N 4720 -2330 4740 -2330 {
lab=Do23}
N 4720 -2310 4740 -2310 {
lab=Do24}
N 4720 -2290 4740 -2290 {
lab=Do25}
N 4720 -2270 4740 -2270 {
lab=Do26}
N 4720 -2250 4740 -2250 {
lab=Do27}
N 4720 -2230 4740 -2230 {
lab=Do28}
N 4720 -2210 4740 -2210 {
lab=Do29}
N 4720 -2190 4740 -2190 {
lab=Do30}
N 4720 -2170 4740 -2170 {
lab=Do31}
N 4730 -1840 4750 -1840 {
lab=Do0}
N 4730 -1820 4750 -1820 {
lab=Do1}
N 4730 -1800 4750 -1800 {
lab=Do2}
N 4730 -1780 4750 -1780 {
lab=Do3}
N 4730 -1760 4750 -1760 {
lab=Do4}
N 4730 -1740 4750 -1740 {
lab=Do5}
N 4730 -1720 4750 -1720 {
lab=Do6}
N 4730 -1700 4750 -1700 {
lab=Do7}
N 4730 -1680 4750 -1680 {
lab=Do8}
N 4730 -1660 4750 -1660 {
lab=Do9}
N 4730 -1640 4750 -1640 {
lab=Do10}
N 4730 -1620 4750 -1620 {
lab=Do11}
N 4730 -1600 4750 -1600 {
lab=Do12}
N 4730 -1580 4750 -1580 {
lab=Do13}
N 4730 -1560 4750 -1560 {
lab=Do14}
N 4730 -1540 4750 -1540 {
lab=Do15}
N 4730 -1520 4750 -1520 {
lab=Do16}
N 4730 -1500 4750 -1500 {
lab=Do17}
N 4730 -1480 4750 -1480 {
lab=Do18}
N 4730 -1460 4750 -1460 {
lab=Do19}
N 4730 -1440 4750 -1440 {
lab=Do20}
N 4730 -1420 4750 -1420 {
lab=Do21}
N 4730 -1400 4750 -1400 {
lab=Do22}
N 4730 -1380 4750 -1380 {
lab=Do23}
N 4730 -1360 4750 -1360 {
lab=Do24}
N 4730 -1340 4750 -1340 {
lab=Do25}
N 4730 -1320 4750 -1320 {
lab=Do26}
N 4730 -1300 4750 -1300 {
lab=Do27}
N 4730 -1280 4750 -1280 {
lab=Do28}
N 4730 -1260 4750 -1260 {
lab=Do29}
N 4730 -1240 4750 -1240 {
lab=Do30}
N 4730 -1220 4750 -1220 {
lab=Do31}
N 4730 -940 4750 -940 {
lab=Do0}
N 4730 -920 4750 -920 {
lab=Do1}
N 4730 -900 4750 -900 {
lab=Do2}
N 4730 -880 4750 -880 {
lab=Do3}
N 4730 -860 4750 -860 {
lab=Do4}
N 4730 -840 4750 -840 {
lab=Do5}
N 4730 -820 4750 -820 {
lab=Do6}
N 4730 -800 4750 -800 {
lab=Do7}
N 4730 -780 4750 -780 {
lab=Do8}
N 4730 -760 4750 -760 {
lab=Do9}
N 4730 -740 4750 -740 {
lab=Do10}
N 4730 -720 4750 -720 {
lab=Do11}
N 4730 -700 4750 -700 {
lab=Do12}
N 4730 -680 4750 -680 {
lab=Do13}
N 4730 -660 4750 -660 {
lab=Do14}
N 4730 -640 4750 -640 {
lab=Do15}
N 4730 -620 4750 -620 {
lab=Do16}
N 4730 -600 4750 -600 {
lab=Do17}
N 4730 -580 4750 -580 {
lab=Do18}
N 4730 -560 4750 -560 {
lab=Do19}
N 4730 -540 4750 -540 {
lab=Do20}
N 4730 -520 4750 -520 {
lab=Do21}
N 4730 -500 4750 -500 {
lab=Do22}
N 4730 -480 4750 -480 {
lab=Do23}
N 4730 -460 4750 -460 {
lab=Do24}
N 4730 -440 4750 -440 {
lab=Do25}
N 4730 -420 4750 -420 {
lab=Do26}
N 4730 -400 4750 -400 {
lab=Do27}
N 4730 -380 4750 -380 {
lab=Do28}
N 4730 -360 4750 -360 {
lab=Do29}
N 4730 -340 4750 -340 {
lab=Do30}
N 4730 -320 4750 -320 {
lab=Do31}
N 5240 -2790 5260 -2790 {
lab=Do0}
N 5240 -2770 5260 -2770 {
lab=Do1}
N 5240 -2750 5260 -2750 {
lab=Do2}
N 5240 -2730 5260 -2730 {
lab=Do3}
N 5240 -2710 5260 -2710 {
lab=Do4}
N 5240 -2690 5260 -2690 {
lab=Do5}
N 5240 -2670 5260 -2670 {
lab=Do6}
N 5240 -2650 5260 -2650 {
lab=Do7}
N 5240 -2630 5260 -2630 {
lab=Do8}
N 5240 -2610 5260 -2610 {
lab=Do9}
N 5240 -2590 5260 -2590 {
lab=Do10}
N 5240 -2570 5260 -2570 {
lab=Do11}
N 5240 -2550 5260 -2550 {
lab=Do12}
N 5240 -2530 5260 -2530 {
lab=Do13}
N 5240 -2510 5260 -2510 {
lab=Do14}
N 5240 -2490 5260 -2490 {
lab=Do15}
N 5240 -2470 5260 -2470 {
lab=Do16}
N 5240 -2450 5260 -2450 {
lab=Do17}
N 5240 -2430 5260 -2430 {
lab=Do18}
N 5240 -2410 5260 -2410 {
lab=Do19}
N 5240 -2390 5260 -2390 {
lab=Do20}
N 5240 -2370 5260 -2370 {
lab=Do21}
N 5240 -2350 5260 -2350 {
lab=Do22}
N 5240 -2330 5260 -2330 {
lab=Do23}
N 5240 -2310 5260 -2310 {
lab=Do24}
N 5240 -2290 5260 -2290 {
lab=Do25}
N 5240 -2270 5260 -2270 {
lab=Do26}
N 5240 -2250 5260 -2250 {
lab=Do27}
N 5240 -2230 5260 -2230 {
lab=Do28}
N 5240 -2210 5260 -2210 {
lab=Do29}
N 5240 -2190 5260 -2190 {
lab=Do30}
N 5240 -2170 5260 -2170 {
lab=Do31}
N 5250 -1840 5270 -1840 {
lab=Do0}
N 5250 -1820 5270 -1820 {
lab=Do1}
N 5250 -1800 5270 -1800 {
lab=Do2}
N 5250 -1780 5270 -1780 {
lab=Do3}
N 5250 -1760 5270 -1760 {
lab=Do4}
N 5250 -1740 5270 -1740 {
lab=Do5}
N 5250 -1720 5270 -1720 {
lab=Do6}
N 5250 -1700 5270 -1700 {
lab=Do7}
N 5250 -1680 5270 -1680 {
lab=Do8}
N 5250 -1660 5270 -1660 {
lab=Do9}
N 5250 -1640 5270 -1640 {
lab=Do10}
N 5250 -1620 5270 -1620 {
lab=Do11}
N 5250 -1600 5270 -1600 {
lab=Do12}
N 5250 -1580 5270 -1580 {
lab=Do13}
N 5250 -1560 5270 -1560 {
lab=Do14}
N 5250 -1540 5270 -1540 {
lab=Do15}
N 5250 -1520 5270 -1520 {
lab=Do16}
N 5250 -1500 5270 -1500 {
lab=Do17}
N 5250 -1480 5270 -1480 {
lab=Do18}
N 5250 -1460 5270 -1460 {
lab=Do19}
N 5250 -1440 5270 -1440 {
lab=Do20}
N 5250 -1420 5270 -1420 {
lab=Do21}
N 5250 -1400 5270 -1400 {
lab=Do22}
N 5250 -1380 5270 -1380 {
lab=Do23}
N 5250 -1360 5270 -1360 {
lab=Do24}
N 5250 -1340 5270 -1340 {
lab=Do25}
N 5250 -1320 5270 -1320 {
lab=Do26}
N 5250 -1300 5270 -1300 {
lab=Do27}
N 5250 -1280 5270 -1280 {
lab=Do28}
N 5250 -1260 5270 -1260 {
lab=Do29}
N 5250 -1240 5270 -1240 {
lab=Do30}
N 5250 -1220 5270 -1220 {
lab=Do31}
N 5250 -940 5270 -940 {
lab=Do0}
N 5250 -920 5270 -920 {
lab=Do1}
N 5250 -900 5270 -900 {
lab=Do2}
N 5250 -880 5270 -880 {
lab=Do3}
N 5250 -860 5270 -860 {
lab=Do4}
N 5250 -840 5270 -840 {
lab=Do5}
N 5250 -820 5270 -820 {
lab=Do6}
N 5250 -800 5270 -800 {
lab=Do7}
N 5250 -780 5270 -780 {
lab=Do8}
N 5250 -760 5270 -760 {
lab=Do9}
N 5250 -740 5270 -740 {
lab=Do10}
N 5250 -720 5270 -720 {
lab=Do11}
N 5250 -700 5270 -700 {
lab=Do12}
N 5250 -680 5270 -680 {
lab=Do13}
N 5250 -660 5270 -660 {
lab=Do14}
N 5250 -640 5270 -640 {
lab=Do15}
N 5250 -620 5270 -620 {
lab=Do16}
N 5250 -600 5270 -600 {
lab=Do17}
N 5250 -580 5270 -580 {
lab=Do18}
N 5250 -560 5270 -560 {
lab=Do19}
N 5250 -540 5270 -540 {
lab=Do20}
N 5250 -520 5270 -520 {
lab=Do21}
N 5250 -500 5270 -500 {
lab=Do22}
N 5250 -480 5270 -480 {
lab=Do23}
N 5250 -460 5270 -460 {
lab=Do24}
N 5250 -440 5270 -440 {
lab=Do25}
N 5250 -420 5270 -420 {
lab=Do26}
N 5250 -400 5270 -400 {
lab=Do27}
N 5250 -380 5270 -380 {
lab=Do28}
N 5250 -360 5270 -360 {
lab=Do29}
N 5250 -340 5270 -340 {
lab=Do30}
N 5250 -320 5270 -320 {
lab=Do31}
N 5760 -2790 5780 -2790 {
lab=Do0}
N 5760 -2770 5780 -2770 {
lab=Do1}
N 5760 -2750 5780 -2750 {
lab=Do2}
N 5760 -2730 5780 -2730 {
lab=Do3}
N 5760 -2710 5780 -2710 {
lab=Do4}
N 5760 -2690 5780 -2690 {
lab=Do5}
N 5760 -2670 5780 -2670 {
lab=Do6}
N 5760 -2650 5780 -2650 {
lab=Do7}
N 5760 -2630 5780 -2630 {
lab=Do8}
N 5760 -2610 5780 -2610 {
lab=Do9}
N 5760 -2590 5780 -2590 {
lab=Do10}
N 5760 -2570 5780 -2570 {
lab=Do11}
N 5760 -2550 5780 -2550 {
lab=Do12}
N 5760 -2530 5780 -2530 {
lab=Do13}
N 5760 -2510 5780 -2510 {
lab=Do14}
N 5760 -2490 5780 -2490 {
lab=Do15}
N 5760 -2470 5780 -2470 {
lab=Do16}
N 5760 -2450 5780 -2450 {
lab=Do17}
N 5760 -2430 5780 -2430 {
lab=Do18}
N 5760 -2410 5780 -2410 {
lab=Do19}
N 5760 -2390 5780 -2390 {
lab=Do20}
N 5760 -2370 5780 -2370 {
lab=Do21}
N 5760 -2350 5780 -2350 {
lab=Do22}
N 5760 -2330 5780 -2330 {
lab=Do23}
N 5760 -2310 5780 -2310 {
lab=Do24}
N 5760 -2290 5780 -2290 {
lab=Do25}
N 5760 -2270 5780 -2270 {
lab=Do26}
N 5760 -2250 5780 -2250 {
lab=Do27}
N 5760 -2230 5780 -2230 {
lab=Do28}
N 5760 -2210 5780 -2210 {
lab=Do29}
N 5760 -2190 5780 -2190 {
lab=Do30}
N 5760 -2170 5780 -2170 {
lab=Do31}
N 5770 -1840 5790 -1840 {
lab=Do0}
N 5770 -1820 5790 -1820 {
lab=Do1}
N 5770 -1800 5790 -1800 {
lab=Do2}
N 5770 -1780 5790 -1780 {
lab=Do3}
N 5770 -1760 5790 -1760 {
lab=Do4}
N 5770 -1740 5790 -1740 {
lab=Do5}
N 5770 -1720 5790 -1720 {
lab=Do6}
N 5770 -1700 5790 -1700 {
lab=Do7}
N 5770 -1680 5790 -1680 {
lab=Do8}
N 5770 -1660 5790 -1660 {
lab=Do9}
N 5770 -1640 5790 -1640 {
lab=Do10}
N 5770 -1620 5790 -1620 {
lab=Do11}
N 5770 -1600 5790 -1600 {
lab=Do12}
N 5770 -1580 5790 -1580 {
lab=Do13}
N 5770 -1560 5790 -1560 {
lab=Do14}
N 5770 -1540 5790 -1540 {
lab=Do15}
N 5770 -1520 5790 -1520 {
lab=Do16}
N 5770 -1500 5790 -1500 {
lab=Do17}
N 5770 -1480 5790 -1480 {
lab=Do18}
N 5770 -1460 5790 -1460 {
lab=Do19}
N 5770 -1440 5790 -1440 {
lab=Do20}
N 5770 -1420 5790 -1420 {
lab=Do21}
N 5770 -1400 5790 -1400 {
lab=Do22}
N 5770 -1380 5790 -1380 {
lab=Do23}
N 5770 -1360 5790 -1360 {
lab=Do24}
N 5770 -1340 5790 -1340 {
lab=Do25}
N 5770 -1320 5790 -1320 {
lab=Do26}
N 5770 -1300 5790 -1300 {
lab=Do27}
N 5770 -1280 5790 -1280 {
lab=Do28}
N 5770 -1260 5790 -1260 {
lab=Do29}
N 5770 -1240 5790 -1240 {
lab=Do30}
N 5770 -1220 5790 -1220 {
lab=Do31}
N 5770 -940 5790 -940 {
lab=Do0}
N 5770 -920 5790 -920 {
lab=Do1}
N 5770 -900 5790 -900 {
lab=Do2}
N 5770 -880 5790 -880 {
lab=Do3}
N 5770 -860 5790 -860 {
lab=Do4}
N 5770 -840 5790 -840 {
lab=Do5}
N 5770 -820 5790 -820 {
lab=Do6}
N 5770 -800 5790 -800 {
lab=Do7}
N 5770 -780 5790 -780 {
lab=Do8}
N 5770 -760 5790 -760 {
lab=Do9}
N 5770 -740 5790 -740 {
lab=Do10}
N 5770 -720 5790 -720 {
lab=Do11}
N 5770 -700 5790 -700 {
lab=Do12}
N 5770 -680 5790 -680 {
lab=Do13}
N 5770 -660 5790 -660 {
lab=Do14}
N 5770 -640 5790 -640 {
lab=Do15}
N 5770 -620 5790 -620 {
lab=Do16}
N 5770 -600 5790 -600 {
lab=Do17}
N 5770 -580 5790 -580 {
lab=Do18}
N 5770 -560 5790 -560 {
lab=Do19}
N 5770 -540 5790 -540 {
lab=Do20}
N 5770 -520 5790 -520 {
lab=Do21}
N 5770 -500 5790 -500 {
lab=Do22}
N 5770 -480 5790 -480 {
lab=Do23}
N 5770 -460 5790 -460 {
lab=Do24}
N 5770 -440 5790 -440 {
lab=Do25}
N 5770 -420 5790 -420 {
lab=Do26}
N 5770 -400 5790 -400 {
lab=Do27}
N 5770 -380 5790 -380 {
lab=Do28}
N 5770 -360 5790 -360 {
lab=Do29}
N 5770 -340 5790 -340 {
lab=Do30}
N 5770 -320 5790 -320 {
lab=Do31}
N 6300 -2790 6320 -2790 {
lab=Do0}
N 6300 -2770 6320 -2770 {
lab=Do1}
N 6300 -2750 6320 -2750 {
lab=Do2}
N 6300 -2730 6320 -2730 {
lab=Do3}
N 6300 -2710 6320 -2710 {
lab=Do4}
N 6300 -2690 6320 -2690 {
lab=Do5}
N 6300 -2670 6320 -2670 {
lab=Do6}
N 6300 -2650 6320 -2650 {
lab=Do7}
N 6300 -2630 6320 -2630 {
lab=Do8}
N 6300 -2610 6320 -2610 {
lab=Do9}
N 6300 -2590 6320 -2590 {
lab=Do10}
N 6300 -2570 6320 -2570 {
lab=Do11}
N 6300 -2550 6320 -2550 {
lab=Do12}
N 6300 -2530 6320 -2530 {
lab=Do13}
N 6300 -2510 6320 -2510 {
lab=Do14}
N 6300 -2490 6320 -2490 {
lab=Do15}
N 6300 -2470 6320 -2470 {
lab=Do16}
N 6300 -2450 6320 -2450 {
lab=Do17}
N 6300 -2430 6320 -2430 {
lab=Do18}
N 6300 -2410 6320 -2410 {
lab=Do19}
N 6300 -2390 6320 -2390 {
lab=Do20}
N 6300 -2370 6320 -2370 {
lab=Do21}
N 6300 -2350 6320 -2350 {
lab=Do22}
N 6300 -2330 6320 -2330 {
lab=Do23}
N 6300 -2310 6320 -2310 {
lab=Do24}
N 6300 -2290 6320 -2290 {
lab=Do25}
N 6300 -2270 6320 -2270 {
lab=Do26}
N 6300 -2250 6320 -2250 {
lab=Do27}
N 6300 -2230 6320 -2230 {
lab=Do28}
N 6300 -2210 6320 -2210 {
lab=Do29}
N 6300 -2190 6320 -2190 {
lab=Do30}
N 6300 -2170 6320 -2170 {
lab=Do31}
N 6310 -1840 6330 -1840 {
lab=Do0}
N 6310 -1820 6330 -1820 {
lab=Do1}
N 6310 -1800 6330 -1800 {
lab=Do2}
N 6310 -1780 6330 -1780 {
lab=Do3}
N 6310 -1760 6330 -1760 {
lab=Do4}
N 6310 -1740 6330 -1740 {
lab=Do5}
N 6310 -1720 6330 -1720 {
lab=Do6}
N 6310 -1700 6330 -1700 {
lab=Do7}
N 6310 -1680 6330 -1680 {
lab=Do8}
N 6310 -1660 6330 -1660 {
lab=Do9}
N 6310 -1640 6330 -1640 {
lab=Do10}
N 6310 -1620 6330 -1620 {
lab=Do11}
N 6310 -1600 6330 -1600 {
lab=Do12}
N 6310 -1580 6330 -1580 {
lab=Do13}
N 6310 -1560 6330 -1560 {
lab=Do14}
N 6310 -1540 6330 -1540 {
lab=Do15}
N 6310 -1520 6330 -1520 {
lab=Do16}
N 6310 -1500 6330 -1500 {
lab=Do17}
N 6310 -1480 6330 -1480 {
lab=Do18}
N 6310 -1460 6330 -1460 {
lab=Do19}
N 6310 -1440 6330 -1440 {
lab=Do20}
N 6310 -1420 6330 -1420 {
lab=Do21}
N 6310 -1400 6330 -1400 {
lab=Do22}
N 6310 -1380 6330 -1380 {
lab=Do23}
N 6310 -1360 6330 -1360 {
lab=Do24}
N 6310 -1340 6330 -1340 {
lab=Do25}
N 6310 -1320 6330 -1320 {
lab=Do26}
N 6310 -1300 6330 -1300 {
lab=Do27}
N 6310 -1280 6330 -1280 {
lab=Do28}
N 6310 -1260 6330 -1260 {
lab=Do29}
N 6310 -1240 6330 -1240 {
lab=Do30}
N 6310 -1220 6330 -1220 {
lab=Do31}
N 6310 -940 6330 -940 {
lab=Do0}
N 6310 -920 6330 -920 {
lab=Do1}
N 6310 -900 6330 -900 {
lab=Do2}
N 6310 -880 6330 -880 {
lab=Do3}
N 6310 -860 6330 -860 {
lab=Do4}
N 6310 -840 6330 -840 {
lab=Do5}
N 6310 -820 6330 -820 {
lab=Do6}
N 6310 -800 6330 -800 {
lab=Do7}
N 6310 -780 6330 -780 {
lab=Do8}
N 6310 -760 6330 -760 {
lab=Do9}
N 6310 -740 6330 -740 {
lab=Do10}
N 6310 -720 6330 -720 {
lab=Do11}
N 6310 -700 6330 -700 {
lab=Do12}
N 6310 -680 6330 -680 {
lab=Do13}
N 6310 -660 6330 -660 {
lab=Do14}
N 6310 -640 6330 -640 {
lab=Do15}
N 6310 -620 6330 -620 {
lab=Do16}
N 6310 -600 6330 -600 {
lab=Do17}
N 6310 -580 6330 -580 {
lab=Do18}
N 6310 -560 6330 -560 {
lab=Do19}
N 6310 -540 6330 -540 {
lab=Do20}
N 6310 -520 6330 -520 {
lab=Do21}
N 6310 -500 6330 -500 {
lab=Do22}
N 6310 -480 6330 -480 {
lab=Do23}
N 6310 -460 6330 -460 {
lab=Do24}
N 6310 -440 6330 -440 {
lab=Do25}
N 6310 -420 6330 -420 {
lab=Do26}
N 6310 -400 6330 -400 {
lab=Do27}
N 6310 -380 6330 -380 {
lab=Do28}
N 6310 -360 6330 -360 {
lab=Do29}
N 6310 -340 6330 -340 {
lab=Do30}
N 6310 -320 6330 -320 {
lab=Do31}
N 6820 -2790 6840 -2790 {
lab=Do0}
N 6820 -2770 6840 -2770 {
lab=Do1}
N 6820 -2750 6840 -2750 {
lab=Do2}
N 6820 -2730 6840 -2730 {
lab=Do3}
N 6820 -2710 6840 -2710 {
lab=Do4}
N 6820 -2690 6840 -2690 {
lab=Do5}
N 6820 -2670 6840 -2670 {
lab=Do6}
N 6820 -2650 6840 -2650 {
lab=Do7}
N 6820 -2630 6840 -2630 {
lab=Do8}
N 6820 -2610 6840 -2610 {
lab=Do9}
N 6820 -2590 6840 -2590 {
lab=Do10}
N 6820 -2570 6840 -2570 {
lab=Do11}
N 6820 -2550 6840 -2550 {
lab=Do12}
N 6820 -2530 6840 -2530 {
lab=Do13}
N 6820 -2510 6840 -2510 {
lab=Do14}
N 6820 -2490 6840 -2490 {
lab=Do15}
N 6820 -2470 6840 -2470 {
lab=Do16}
N 6820 -2450 6840 -2450 {
lab=Do17}
N 6820 -2430 6840 -2430 {
lab=Do18}
N 6820 -2410 6840 -2410 {
lab=Do19}
N 6820 -2390 6840 -2390 {
lab=Do20}
N 6820 -2370 6840 -2370 {
lab=Do21}
N 6820 -2350 6840 -2350 {
lab=Do22}
N 6820 -2330 6840 -2330 {
lab=Do23}
N 6820 -2310 6840 -2310 {
lab=Do24}
N 6820 -2290 6840 -2290 {
lab=Do25}
N 6820 -2270 6840 -2270 {
lab=Do26}
N 6820 -2250 6840 -2250 {
lab=Do27}
N 6820 -2230 6840 -2230 {
lab=Do28}
N 6820 -2210 6840 -2210 {
lab=Do29}
N 6820 -2190 6840 -2190 {
lab=Do30}
N 6820 -2170 6840 -2170 {
lab=Do31}
N 6830 -1840 6850 -1840 {
lab=Do0}
N 6830 -1820 6850 -1820 {
lab=Do1}
N 6830 -1800 6850 -1800 {
lab=Do2}
N 6830 -1780 6850 -1780 {
lab=Do3}
N 6830 -1760 6850 -1760 {
lab=Do4}
N 6830 -1740 6850 -1740 {
lab=Do5}
N 6830 -1720 6850 -1720 {
lab=Do6}
N 6830 -1700 6850 -1700 {
lab=Do7}
N 6830 -1680 6850 -1680 {
lab=Do8}
N 6830 -1660 6850 -1660 {
lab=Do9}
N 6830 -1640 6850 -1640 {
lab=Do10}
N 6830 -1620 6850 -1620 {
lab=Do11}
N 6830 -1600 6850 -1600 {
lab=Do12}
N 6830 -1580 6850 -1580 {
lab=Do13}
N 6830 -1560 6850 -1560 {
lab=Do14}
N 6830 -1540 6850 -1540 {
lab=Do15}
N 6830 -1520 6850 -1520 {
lab=Do16}
N 6830 -1500 6850 -1500 {
lab=Do17}
N 6830 -1480 6850 -1480 {
lab=Do18}
N 6830 -1460 6850 -1460 {
lab=Do19}
N 6830 -1440 6850 -1440 {
lab=Do20}
N 6830 -1420 6850 -1420 {
lab=Do21}
N 6830 -1400 6850 -1400 {
lab=Do22}
N 6830 -1380 6850 -1380 {
lab=Do23}
N 6830 -1360 6850 -1360 {
lab=Do24}
N 6830 -1340 6850 -1340 {
lab=Do25}
N 6830 -1320 6850 -1320 {
lab=Do26}
N 6830 -1300 6850 -1300 {
lab=Do27}
N 6830 -1280 6850 -1280 {
lab=Do28}
N 6830 -1260 6850 -1260 {
lab=Do29}
N 6830 -1240 6850 -1240 {
lab=Do30}
N 6830 -1220 6850 -1220 {
lab=Do31}
N 6830 -940 6850 -940 {
lab=Do0}
N 6830 -920 6850 -920 {
lab=Do1}
N 6830 -900 6850 -900 {
lab=Do2}
N 6830 -880 6850 -880 {
lab=Do3}
N 6830 -860 6850 -860 {
lab=Do4}
N 6830 -840 6850 -840 {
lab=Do5}
N 6830 -820 6850 -820 {
lab=Do6}
N 6830 -800 6850 -800 {
lab=Do7}
N 6830 -780 6850 -780 {
lab=Do8}
N 6830 -760 6850 -760 {
lab=Do9}
N 6830 -740 6850 -740 {
lab=Do10}
N 6830 -720 6850 -720 {
lab=Do11}
N 6830 -700 6850 -700 {
lab=Do12}
N 6830 -680 6850 -680 {
lab=Do13}
N 6830 -660 6850 -660 {
lab=Do14}
N 6830 -640 6850 -640 {
lab=Do15}
N 6830 -620 6850 -620 {
lab=Do16}
N 6830 -600 6850 -600 {
lab=Do17}
N 6830 -580 6850 -580 {
lab=Do18}
N 6830 -560 6850 -560 {
lab=Do19}
N 6830 -540 6850 -540 {
lab=Do20}
N 6830 -520 6850 -520 {
lab=Do21}
N 6830 -500 6850 -500 {
lab=Do22}
N 6830 -480 6850 -480 {
lab=Do23}
N 6830 -460 6850 -460 {
lab=Do24}
N 6830 -440 6850 -440 {
lab=Do25}
N 6830 -420 6850 -420 {
lab=Do26}
N 6830 -400 6850 -400 {
lab=Do27}
N 6830 -380 6850 -380 {
lab=Do28}
N 6830 -360 6850 -360 {
lab=Do29}
N 6830 -340 6850 -340 {
lab=Do30}
N 6830 -320 6850 -320 {
lab=Do31}
C {devices/ipin.sym} 90 -3990 0 0 {name=p7 lab=Di0}
C {devices/opin.sym} 50 -3680 0 0 {name=p39 lab=Do0}
C {devices/ipin.sym} 180 -3990 0 0 {name=p8 lab=Di1}
C {devices/opin.sym} 140 -3680 0 0 {name=p40 lab=Do1}
C {devices/ipin.sym} 270 -3990 0 0 {name=p9 lab=Di2}
C {devices/opin.sym} 230 -3680 0 0 {name=p41 lab=Do2}
C {devices/ipin.sym} 360 -3990 0 0 {name=p10 lab=Di3}
C {devices/opin.sym} 320 -3680 0 0 {name=p42 lab=Do3}
C {devices/ipin.sym} 90 -3960 0 0 {name=p11 lab=Di4}
C {devices/opin.sym} 50 -3650 0 0 {name=p43 lab=Do4}
C {devices/ipin.sym} 180 -3960 0 0 {name=p12 lab=Di5}
C {devices/opin.sym} 140 -3650 0 0 {name=p44 lab=Do5}
C {devices/ipin.sym} 270 -3960 0 0 {name=p13 lab=Di6}
C {devices/opin.sym} 230 -3650 0 0 {name=p45 lab=Do6}
C {devices/ipin.sym} 360 -3960 0 0 {name=p14 lab=Di7}
C {devices/opin.sym} 320 -3650 0 0 {name=p46 lab=Do7}
C {devices/ipin.sym} 90 -3930 0 0 {name=p15 lab=Di8}
C {devices/opin.sym} 50 -3620 0 0 {name=p47 lab=Do8}
C {devices/ipin.sym} 180 -3930 0 0 {name=p16 lab=Di9}
C {devices/opin.sym} 140 -3620 0 0 {name=p48 lab=Do9}
C {devices/ipin.sym} 270 -3930 0 0 {name=p17 lab=Di10}
C {devices/opin.sym} 230 -3620 0 0 {name=p49 lab=Do10}
C {devices/ipin.sym} 360 -3930 0 0 {name=p18 lab=D11}
C {devices/opin.sym} 320 -3620 0 0 {name=p50 lab=Do11}
C {devices/ipin.sym} 90 -3900 0 0 {name=p19 lab=Di12}
C {devices/opin.sym} 50 -3590 0 0 {name=p51 lab=Do12}
C {devices/ipin.sym} 180 -3900 0 0 {name=p20 lab=Di13}
C {devices/opin.sym} 140 -3590 0 0 {name=p52 lab=Do13}
C {devices/ipin.sym} 270 -3900 0 0 {name=p21 lab=Di14}
C {devices/opin.sym} 230 -3590 0 0 {name=p53 lab=Do14}
C {devices/ipin.sym} 360 -3900 0 0 {name=p22 lab=Di15}
C {devices/opin.sym} 320 -3590 0 0 {name=p54 lab=Do15}
C {devices/ipin.sym} 90 -3870 0 0 {name=p23 lab=Di16}
C {devices/opin.sym} 50 -3560 0 0 {name=p55 lab=Do16}
C {devices/ipin.sym} 180 -3870 0 0 {name=p24 lab=Di17}
C {devices/opin.sym} 140 -3560 0 0 {name=p56 lab=Do17}
C {devices/ipin.sym} 270 -3870 0 0 {name=p25 lab=Di18}
C {devices/opin.sym} 230 -3560 0 0 {name=p57 lab=Do18}
C {devices/ipin.sym} 360 -3870 0 0 {name=p26 lab=Di19}
C {devices/opin.sym} 320 -3560 0 0 {name=p58 lab=Do19}
C {devices/ipin.sym} 90 -3840 0 0 {name=p27 lab=Di20}
C {devices/opin.sym} 50 -3530 0 0 {name=p59 lab=Do20}
C {devices/ipin.sym} 180 -3840 0 0 {name=p28 lab=Di21}
C {devices/opin.sym} 140 -3530 0 0 {name=p60 lab=Do21}
C {devices/ipin.sym} 270 -3840 0 0 {name=p29 lab=Di22}
C {devices/opin.sym} 230 -3530 0 0 {name=p61 lab=Do22}
C {devices/ipin.sym} 360 -3840 0 0 {name=p30 lab=Di23}
C {devices/opin.sym} 320 -3530 0 0 {name=p62 lab=Do23}
C {devices/ipin.sym} 90 -3810 0 0 {name=p31 lab=Di24}
C {devices/opin.sym} 50 -3500 0 0 {name=p63 lab=Do24}
C {devices/ipin.sym} 180 -3810 0 0 {name=p32 lab=Di25}
C {devices/opin.sym} 140 -3500 0 0 {name=p64 lab=Do25}
C {devices/ipin.sym} 270 -3810 0 0 {name=p33 lab=Di26}
C {devices/opin.sym} 230 -3500 0 0 {name=p65 lab=Do26}
C {devices/ipin.sym} 360 -3810 0 0 {name=p34 lab=Di27}
C {devices/opin.sym} 320 -3500 0 0 {name=p66 lab=Do27}
C {devices/ipin.sym} 90 -3780 0 0 {name=p35 lab=Di28}
C {devices/opin.sym} 50 -3470 0 0 {name=p67 lab=Do28}
C {devices/ipin.sym} 180 -3780 0 0 {name=p36 lab=Di29}
C {devices/opin.sym} 140 -3470 0 0 {name=p68 lab=Do29}
C {devices/ipin.sym} 270 -3780 0 0 {name=p37 lab=Di30}
C {devices/opin.sym} 230 -3470 0 0 {name=p69 lab=Do30}
C {devices/ipin.sym} 360 -3780 0 0 {name=p38 lab=Di31}
C {devices/opin.sym} 320 -3470 0 0 {name=p70 lab=Do31}
C {iopin.sym} 490 -3990 0 0 {name=p71 lab=VDD}
C {iopin.sym} 490 -3960 0 0 {name=p72 lab=VSS}
C {ipin.sym} 540 -3910 0 0 {name=p73 lab=WE0}
C {ipin.sym} 540 -3880 0 0 {name=p74 lab=WE1}
C {ipin.sym} 540 -3850 0 0 {name=p75 lab=WE2}
C {ipin.sym} 540 -3820 0 0 {name=p76 lab=WE3}
C {ipin.sym} 540 -3780 0 0 {name=p77 lab=CLK}
C {xschem_lib/DFFRAM_full_custom/word.sym} 2990 -3440 0 0 {name=xbyte1 NF=2}
C {lab_wire.sym} 2820 -3690 0 0 {name=l1 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 2820 -3670 0 0 {name=l2 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 2820 -3650 0 0 {name=l3 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 2820 -3630 0 0 {name=l4 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 2820 -3610 0 0 {name=l5 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 2820 -3590 0 0 {name=l6 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 2820 -3570 0 0 {name=l7 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 2820 -3550 0 0 {name=l8 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 2820 -3530 0 0 {name=l9 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 2820 -3510 0 0 {name=l10 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 2820 -3490 0 0 {name=l11 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 2820 -3470 0 0 {name=l12 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 2820 -3450 0 0 {name=l13 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 2820 -3430 0 0 {name=l14 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 2820 -3410 0 0 {name=l15 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 2820 -3390 0 0 {name=l16 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 2820 -3370 0 0 {name=l17 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 2820 -3350 0 0 {name=l18 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2820 -3330 0 0 {name=l19 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2820 -3310 0 0 {name=l20 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2820 -3290 0 0 {name=l21 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2820 -3270 0 0 {name=l22 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2820 -3250 0 0 {name=l23 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2820 -3230 0 0 {name=l24 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2820 -3210 0 0 {name=l25 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2820 -3190 0 0 {name=l26 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2820 -3170 0 0 {name=l27 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2820 -3150 0 0 {name=l28 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2820 -3130 0 0 {name=l29 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2820 -3110 0 0 {name=l30 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2820 -3070 0 0 {name=l31 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2820 -3090 0 0 {name=l32 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3160 -3690 2 0 {name=l33 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 3160 -3670 2 0 {name=l34 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 3160 -3650 2 0 {name=l35 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 3160 -3630 2 0 {name=l36 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 3160 -3610 2 0 {name=l37 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 3160 -3590 2 0 {name=l38 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 3160 -3570 2 0 {name=l39 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 3160 -3550 2 0 {name=l40 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 3160 -3530 2 0 {name=l41 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 3160 -3510 2 0 {name=l42 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 3160 -3490 2 0 {name=l43 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 3160 -3470 2 0 {name=l44 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 3160 -3450 2 0 {name=l45 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 3160 -3430 2 0 {name=l46 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 3160 -3410 2 0 {name=l47 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 3160 -3390 2 0 {name=l48 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 3160 -3370 2 0 {name=l49 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 3160 -3350 2 0 {name=l50 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 3160 -3330 2 0 {name=l51 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 3160 -3310 2 0 {name=l52 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 3160 -3290 2 0 {name=l53 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 3160 -3270 2 0 {name=l54 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 3160 -3250 2 0 {name=l55 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 3160 -3230 2 0 {name=l56 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 3160 -3210 2 0 {name=l57 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 3160 -3190 2 0 {name=l58 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 3160 -3170 2 0 {name=l59 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 3160 -3150 2 0 {name=l60 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 3160 -3130 2 0 {name=l61 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 3160 -3110 2 0 {name=l62 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 3160 -3090 2 0 {name=l63 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 3160 -3070 2 0 {name=l64 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 2910 -3750 0 0 {name=l65 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2950 -3750 1 0 {name=l66 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 2970 -3750 1 0 {name=l67 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 2990 -3750 1 0 {name=l68 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 3010 -3750 1 0 {name=l69 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 3040 -3750 1 0 {name=l70 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3060 -3750 1 0 {name=l71 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 3510 -3440 0 0 {name=xbyte2 NF=2}
C {lab_wire.sym} 3340 -3690 0 0 {name=l72 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 3340 -3670 0 0 {name=l73 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 3340 -3650 0 0 {name=l74 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 3340 -3630 0 0 {name=l75 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 3340 -3610 0 0 {name=l76 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 3340 -3590 0 0 {name=l77 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 3340 -3570 0 0 {name=l78 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 3340 -3550 0 0 {name=l79 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 3340 -3530 0 0 {name=l80 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 3340 -3510 0 0 {name=l81 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 3340 -3490 0 0 {name=l82 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 3340 -3470 0 0 {name=l83 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 3340 -3450 0 0 {name=l84 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 3340 -3430 0 0 {name=l85 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 3340 -3410 0 0 {name=l86 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 3340 -3390 0 0 {name=l87 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 3340 -3370 0 0 {name=l88 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 3340 -3350 0 0 {name=l89 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3340 -3330 0 0 {name=l90 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3340 -3310 0 0 {name=l91 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3340 -3290 0 0 {name=l92 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3340 -3270 0 0 {name=l93 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3340 -3250 0 0 {name=l94 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3340 -3230 0 0 {name=l95 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3340 -3210 0 0 {name=l96 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3340 -3190 0 0 {name=l97 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3340 -3170 0 0 {name=l98 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3340 -3150 0 0 {name=l99 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3340 -3130 0 0 {name=l100 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3340 -3110 0 0 {name=l101 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3340 -3070 0 0 {name=l102 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3340 -3090 0 0 {name=l103 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3430 -3750 0 0 {name=l136 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3470 -3750 1 0 {name=l137 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 3490 -3750 1 0 {name=l138 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 3510 -3750 1 0 {name=l139 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 3530 -3750 1 0 {name=l140 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 3560 -3750 1 0 {name=l141 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3580 -3750 1 0 {name=l142 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 4050 -3440 0 0 {name=xbyte3 NF=2}
C {lab_wire.sym} 3880 -3690 0 0 {name=l143 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 3880 -3670 0 0 {name=l144 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 3880 -3650 0 0 {name=l145 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 3880 -3630 0 0 {name=l146 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 3880 -3610 0 0 {name=l147 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 3880 -3590 0 0 {name=l148 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 3880 -3570 0 0 {name=l149 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 3880 -3550 0 0 {name=l150 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 3880 -3530 0 0 {name=l151 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 3880 -3510 0 0 {name=l152 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 3880 -3490 0 0 {name=l153 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 3880 -3470 0 0 {name=l154 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 3880 -3450 0 0 {name=l155 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 3880 -3430 0 0 {name=l156 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 3880 -3410 0 0 {name=l157 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 3880 -3390 0 0 {name=l158 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 3880 -3370 0 0 {name=l159 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 3880 -3350 0 0 {name=l160 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3880 -3330 0 0 {name=l161 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3880 -3310 0 0 {name=l162 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3880 -3290 0 0 {name=l163 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3880 -3270 0 0 {name=l164 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3880 -3250 0 0 {name=l165 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3880 -3230 0 0 {name=l166 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3880 -3210 0 0 {name=l167 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3880 -3190 0 0 {name=l168 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3880 -3170 0 0 {name=l169 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3880 -3150 0 0 {name=l170 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3880 -3130 0 0 {name=l171 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3880 -3110 0 0 {name=l172 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3880 -3070 0 0 {name=l173 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3880 -3090 0 0 {name=l174 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3970 -3750 0 0 {name=l207 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 4010 -3750 1 0 {name=l208 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 4030 -3750 1 0 {name=l209 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 4050 -3750 1 0 {name=l210 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 4070 -3750 1 0 {name=l211 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 4100 -3750 1 0 {name=l212 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4120 -3750 1 0 {name=l213 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 4570 -3440 0 0 {name=xbyte4 NF=2}
C {lab_wire.sym} 4400 -3690 0 0 {name=l214 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 4400 -3670 0 0 {name=l215 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 4400 -3650 0 0 {name=l216 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 4400 -3630 0 0 {name=l217 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 4400 -3610 0 0 {name=l218 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 4400 -3590 0 0 {name=l219 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 4400 -3570 0 0 {name=l220 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 4400 -3550 0 0 {name=l221 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 4400 -3530 0 0 {name=l222 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 4400 -3510 0 0 {name=l223 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 4400 -3490 0 0 {name=l224 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 4400 -3470 0 0 {name=l225 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 4400 -3450 0 0 {name=l226 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 4400 -3430 0 0 {name=l227 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 4400 -3410 0 0 {name=l228 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 4400 -3390 0 0 {name=l229 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 4400 -3370 0 0 {name=l230 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 4400 -3350 0 0 {name=l231 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 4400 -3330 0 0 {name=l232 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 4400 -3310 0 0 {name=l233 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 4400 -3290 0 0 {name=l234 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 4400 -3270 0 0 {name=l235 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 4400 -3250 0 0 {name=l236 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 4400 -3230 0 0 {name=l237 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 4400 -3210 0 0 {name=l238 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 4400 -3190 0 0 {name=l239 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 4400 -3170 0 0 {name=l240 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 4400 -3150 0 0 {name=l241 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 4400 -3130 0 0 {name=l242 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 4400 -3110 0 0 {name=l243 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 4400 -3070 0 0 {name=l244 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 4400 -3090 0 0 {name=l245 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 4490 -3750 0 0 {name=l278 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 4530 -3750 1 0 {name=l279 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 4550 -3750 1 0 {name=l280 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 4570 -3750 1 0 {name=l281 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 4590 -3750 1 0 {name=l282 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 4620 -3750 1 0 {name=l283 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4640 -3750 1 0 {name=l284 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 5090 -3440 0 0 {name=xbyte5 NF=2}
C {lab_wire.sym} 4920 -3690 0 0 {name=l285 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 4920 -3670 0 0 {name=l286 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 4920 -3650 0 0 {name=l287 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 4920 -3630 0 0 {name=l288 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 4920 -3610 0 0 {name=l289 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 4920 -3590 0 0 {name=l290 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 4920 -3570 0 0 {name=l291 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 4920 -3550 0 0 {name=l292 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 4920 -3530 0 0 {name=l293 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 4920 -3510 0 0 {name=l294 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 4920 -3490 0 0 {name=l295 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 4920 -3470 0 0 {name=l296 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 4920 -3450 0 0 {name=l297 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 4920 -3430 0 0 {name=l298 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 4920 -3410 0 0 {name=l299 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 4920 -3390 0 0 {name=l300 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 4920 -3370 0 0 {name=l301 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 4920 -3350 0 0 {name=l302 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 4920 -3330 0 0 {name=l303 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 4920 -3310 0 0 {name=l304 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 4920 -3290 0 0 {name=l305 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 4920 -3270 0 0 {name=l306 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 4920 -3250 0 0 {name=l307 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 4920 -3230 0 0 {name=l308 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 4920 -3210 0 0 {name=l309 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 4920 -3190 0 0 {name=l310 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 4920 -3170 0 0 {name=l311 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 4920 -3150 0 0 {name=l312 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 4920 -3130 0 0 {name=l313 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 4920 -3110 0 0 {name=l314 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 4920 -3070 0 0 {name=l315 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 4920 -3090 0 0 {name=l316 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 5010 -3750 0 0 {name=l349 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 5050 -3750 1 0 {name=l350 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5070 -3750 1 0 {name=l351 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 5090 -3750 1 0 {name=l352 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 5110 -3750 1 0 {name=l353 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 5140 -3750 1 0 {name=l354 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5160 -3750 1 0 {name=l355 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 5610 -3440 0 0 {name=xbyte6 NF=2}
C {lab_wire.sym} 5440 -3690 0 0 {name=l356 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 5440 -3670 0 0 {name=l357 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 5440 -3650 0 0 {name=l358 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 5440 -3630 0 0 {name=l359 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 5440 -3610 0 0 {name=l360 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 5440 -3590 0 0 {name=l361 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 5440 -3570 0 0 {name=l362 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 5440 -3550 0 0 {name=l363 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 5440 -3530 0 0 {name=l364 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 5440 -3510 0 0 {name=l365 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 5440 -3490 0 0 {name=l366 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 5440 -3470 0 0 {name=l367 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 5440 -3450 0 0 {name=l368 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 5440 -3430 0 0 {name=l369 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 5440 -3410 0 0 {name=l370 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 5440 -3390 0 0 {name=l371 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 5440 -3370 0 0 {name=l372 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 5440 -3350 0 0 {name=l373 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 5440 -3330 0 0 {name=l374 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 5440 -3310 0 0 {name=l375 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 5440 -3290 0 0 {name=l376 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 5440 -3270 0 0 {name=l377 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 5440 -3250 0 0 {name=l378 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 5440 -3230 0 0 {name=l379 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 5440 -3210 0 0 {name=l380 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 5440 -3190 0 0 {name=l381 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 5440 -3170 0 0 {name=l382 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 5440 -3150 0 0 {name=l383 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 5440 -3130 0 0 {name=l384 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 5440 -3110 0 0 {name=l385 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 5440 -3070 0 0 {name=l386 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 5440 -3090 0 0 {name=l387 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 5530 -3750 0 0 {name=l420 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 5570 -3750 1 0 {name=l421 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5590 -3750 1 0 {name=l422 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 5610 -3750 1 0 {name=l423 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 5630 -3750 1 0 {name=l424 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 5660 -3750 1 0 {name=l425 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5680 -3750 1 0 {name=l426 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 6150 -3440 0 0 {name=xbyte7 NF=2}
C {lab_wire.sym} 5980 -3690 0 0 {name=l427 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 5980 -3670 0 0 {name=l428 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 5980 -3650 0 0 {name=l429 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 5980 -3630 0 0 {name=l430 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 5980 -3610 0 0 {name=l431 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 5980 -3590 0 0 {name=l432 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 5980 -3570 0 0 {name=l433 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 5980 -3550 0 0 {name=l434 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 5980 -3530 0 0 {name=l435 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 5980 -3510 0 0 {name=l436 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 5980 -3490 0 0 {name=l437 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 5980 -3470 0 0 {name=l438 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 5980 -3450 0 0 {name=l439 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 5980 -3430 0 0 {name=l440 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 5980 -3410 0 0 {name=l441 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 5980 -3390 0 0 {name=l442 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 5980 -3370 0 0 {name=l443 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 5980 -3350 0 0 {name=l444 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 5980 -3330 0 0 {name=l445 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 5980 -3310 0 0 {name=l446 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 5980 -3290 0 0 {name=l447 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 5980 -3270 0 0 {name=l448 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 5980 -3250 0 0 {name=l449 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 5980 -3230 0 0 {name=l450 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 5980 -3210 0 0 {name=l451 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 5980 -3190 0 0 {name=l452 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 5980 -3170 0 0 {name=l453 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 5980 -3150 0 0 {name=l454 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 5980 -3130 0 0 {name=l455 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 5980 -3110 0 0 {name=l456 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 5980 -3070 0 0 {name=l457 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 5980 -3090 0 0 {name=l458 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 6110 -3750 1 0 {name=l492 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 6130 -3750 1 0 {name=l493 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 6150 -3750 1 0 {name=l494 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 6170 -3750 1 0 {name=l495 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 6200 -3750 1 0 {name=l496 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 6220 -3750 1 0 {name=l497 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 6670 -3440 0 0 {name=xbyte8 NF=2}
C {lab_wire.sym} 6500 -3690 0 0 {name=l498 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 6500 -3670 0 0 {name=l499 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 6500 -3650 0 0 {name=l500 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 6500 -3630 0 0 {name=l501 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 6500 -3610 0 0 {name=l502 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 6500 -3590 0 0 {name=l503 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 6500 -3570 0 0 {name=l504 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 6500 -3550 0 0 {name=l505 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 6500 -3530 0 0 {name=l506 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 6500 -3510 0 0 {name=l507 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 6500 -3490 0 0 {name=l508 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 6500 -3470 0 0 {name=l509 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 6500 -3450 0 0 {name=l510 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 6500 -3430 0 0 {name=l511 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 6500 -3410 0 0 {name=l512 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 6500 -3390 0 0 {name=l513 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 6500 -3370 0 0 {name=l514 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 6500 -3350 0 0 {name=l515 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 6500 -3330 0 0 {name=l516 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 6500 -3310 0 0 {name=l517 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 6500 -3290 0 0 {name=l518 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 6500 -3270 0 0 {name=l519 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 6500 -3250 0 0 {name=l520 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 6500 -3230 0 0 {name=l521 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 6500 -3210 0 0 {name=l522 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 6500 -3190 0 0 {name=l523 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 6500 -3170 0 0 {name=l524 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 6500 -3150 0 0 {name=l525 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 6500 -3130 0 0 {name=l526 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 6500 -3110 0 0 {name=l527 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 6500 -3070 0 0 {name=l528 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 6500 -3090 0 0 {name=l529 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 6630 -3750 1 0 {name=l563 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 6650 -3750 1 0 {name=l564 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 6670 -3750 1 0 {name=l565 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 6690 -3750 1 0 {name=l566 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 6720 -3750 1 0 {name=l567 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 6740 -3750 1 0 {name=l568 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 2990 -2540 0 0 {name=xbyte9 NF=2}
C {lab_wire.sym} 2820 -2790 0 0 {name=l569 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 2820 -2770 0 0 {name=l570 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 2820 -2750 0 0 {name=l571 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 2820 -2730 0 0 {name=l572 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 2820 -2710 0 0 {name=l573 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 2820 -2690 0 0 {name=l574 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 2820 -2670 0 0 {name=l575 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 2820 -2650 0 0 {name=l576 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 2820 -2630 0 0 {name=l577 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 2820 -2610 0 0 {name=l578 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 2820 -2590 0 0 {name=l579 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 2820 -2570 0 0 {name=l580 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 2820 -2550 0 0 {name=l581 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 2820 -2530 0 0 {name=l582 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 2820 -2510 0 0 {name=l583 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 2820 -2490 0 0 {name=l584 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 2820 -2470 0 0 {name=l585 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 2820 -2450 0 0 {name=l586 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2820 -2430 0 0 {name=l587 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2820 -2410 0 0 {name=l588 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2820 -2390 0 0 {name=l589 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2820 -2370 0 0 {name=l590 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2820 -2350 0 0 {name=l591 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2820 -2330 0 0 {name=l592 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2820 -2310 0 0 {name=l593 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2820 -2290 0 0 {name=l594 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2820 -2270 0 0 {name=l595 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2820 -2250 0 0 {name=l596 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2820 -2230 0 0 {name=l597 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2820 -2210 0 0 {name=l598 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2820 -2170 0 0 {name=l599 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2820 -2190 0 0 {name=l600 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2950 -2850 1 0 {name=l634 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 2970 -2850 1 0 {name=l635 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 2990 -2850 1 0 {name=l636 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 3010 -2850 1 0 {name=l637 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 3040 -2850 1 0 {name=l638 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3060 -2850 1 0 {name=l639 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 3510 -2540 0 0 {name=xbyte10 NF=2}
C {lab_wire.sym} 3340 -2790 0 0 {name=l640 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 3340 -2770 0 0 {name=l641 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 3340 -2750 0 0 {name=l642 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 3340 -2730 0 0 {name=l643 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 3340 -2710 0 0 {name=l644 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 3340 -2690 0 0 {name=l645 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 3340 -2670 0 0 {name=l646 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 3340 -2650 0 0 {name=l647 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 3340 -2630 0 0 {name=l648 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 3340 -2610 0 0 {name=l649 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 3340 -2590 0 0 {name=l650 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 3340 -2570 0 0 {name=l651 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 3340 -2550 0 0 {name=l652 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 3340 -2530 0 0 {name=l653 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 3340 -2510 0 0 {name=l654 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 3340 -2490 0 0 {name=l655 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 3340 -2470 0 0 {name=l656 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 3340 -2450 0 0 {name=l657 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3340 -2430 0 0 {name=l658 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3340 -2410 0 0 {name=l659 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3340 -2390 0 0 {name=l660 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3340 -2370 0 0 {name=l661 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3340 -2350 0 0 {name=l662 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3340 -2330 0 0 {name=l663 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3340 -2310 0 0 {name=l664 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3340 -2290 0 0 {name=l665 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3340 -2270 0 0 {name=l666 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3340 -2250 0 0 {name=l667 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3340 -2230 0 0 {name=l668 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3340 -2210 0 0 {name=l669 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3340 -2170 0 0 {name=l670 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3340 -2190 0 0 {name=l671 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3470 -2850 1 0 {name=l705 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 3490 -2850 1 0 {name=l706 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 3510 -2850 1 0 {name=l707 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 3530 -2850 1 0 {name=l708 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 3560 -2850 1 0 {name=l709 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3580 -2850 1 0 {name=l710 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 4050 -2540 0 0 {name=xbyte11 NF=2}
C {lab_wire.sym} 3880 -2790 0 0 {name=l711 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 3880 -2770 0 0 {name=l712 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 3880 -2750 0 0 {name=l713 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 3880 -2730 0 0 {name=l714 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 3880 -2710 0 0 {name=l715 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 3880 -2690 0 0 {name=l716 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 3880 -2670 0 0 {name=l717 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 3880 -2650 0 0 {name=l718 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 3880 -2630 0 0 {name=l719 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 3880 -2610 0 0 {name=l720 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 3880 -2590 0 0 {name=l721 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 3880 -2570 0 0 {name=l722 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 3880 -2550 0 0 {name=l723 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 3880 -2530 0 0 {name=l724 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 3880 -2510 0 0 {name=l725 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 3880 -2490 0 0 {name=l726 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 3880 -2470 0 0 {name=l727 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 3880 -2450 0 0 {name=l728 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3880 -2430 0 0 {name=l729 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3880 -2410 0 0 {name=l730 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3880 -2390 0 0 {name=l731 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3880 -2370 0 0 {name=l732 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3880 -2350 0 0 {name=l733 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3880 -2330 0 0 {name=l734 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3880 -2310 0 0 {name=l735 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3880 -2290 0 0 {name=l736 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3880 -2270 0 0 {name=l737 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3880 -2250 0 0 {name=l738 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3880 -2230 0 0 {name=l739 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3880 -2210 0 0 {name=l740 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3880 -2170 0 0 {name=l741 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3880 -2190 0 0 {name=l742 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 4010 -2850 1 0 {name=l776 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 4030 -2850 1 0 {name=l777 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 4050 -2850 1 0 {name=l778 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 4070 -2850 1 0 {name=l779 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 4100 -2850 1 0 {name=l780 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4120 -2850 1 0 {name=l781 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 4570 -2540 0 0 {name=xbyte12 NF=2}
C {lab_wire.sym} 4400 -2790 0 0 {name=l782 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 4400 -2770 0 0 {name=l783 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 4400 -2750 0 0 {name=l784 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 4400 -2730 0 0 {name=l785 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 4400 -2710 0 0 {name=l786 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 4400 -2690 0 0 {name=l787 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 4400 -2670 0 0 {name=l788 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 4400 -2650 0 0 {name=l789 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 4400 -2630 0 0 {name=l790 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 4400 -2610 0 0 {name=l791 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 4400 -2590 0 0 {name=l792 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 4400 -2570 0 0 {name=l793 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 4400 -2550 0 0 {name=l794 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 4400 -2530 0 0 {name=l795 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 4400 -2510 0 0 {name=l796 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 4400 -2490 0 0 {name=l797 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 4400 -2470 0 0 {name=l798 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 4400 -2450 0 0 {name=l799 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 4400 -2430 0 0 {name=l800 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 4400 -2410 0 0 {name=l801 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 4400 -2390 0 0 {name=l802 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 4400 -2370 0 0 {name=l803 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 4400 -2350 0 0 {name=l804 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 4400 -2330 0 0 {name=l805 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 4400 -2310 0 0 {name=l806 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 4400 -2290 0 0 {name=l807 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 4400 -2270 0 0 {name=l808 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 4400 -2250 0 0 {name=l809 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 4400 -2230 0 0 {name=l810 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 4400 -2210 0 0 {name=l811 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 4400 -2170 0 0 {name=l812 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 4400 -2190 0 0 {name=l813 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 4530 -2850 1 0 {name=l847 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 4550 -2850 1 0 {name=l848 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 4570 -2850 1 0 {name=l849 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 4590 -2850 1 0 {name=l850 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 4620 -2850 1 0 {name=l851 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4640 -2850 1 0 {name=l852 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 5090 -2540 0 0 {name=xbyte13 NF=2}
C {lab_wire.sym} 4920 -2790 0 0 {name=l853 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 4920 -2770 0 0 {name=l854 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 4920 -2750 0 0 {name=l855 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 4920 -2730 0 0 {name=l856 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 4920 -2710 0 0 {name=l857 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 4920 -2690 0 0 {name=l858 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 4920 -2670 0 0 {name=l859 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 4920 -2650 0 0 {name=l860 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 4920 -2630 0 0 {name=l861 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 4920 -2610 0 0 {name=l862 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 4920 -2590 0 0 {name=l863 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 4920 -2570 0 0 {name=l864 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 4920 -2550 0 0 {name=l865 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 4920 -2530 0 0 {name=l866 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 4920 -2510 0 0 {name=l867 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 4920 -2490 0 0 {name=l868 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 4920 -2470 0 0 {name=l869 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 4920 -2450 0 0 {name=l870 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 4920 -2430 0 0 {name=l871 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 4920 -2410 0 0 {name=l872 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 4920 -2390 0 0 {name=l873 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 4920 -2370 0 0 {name=l874 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 4920 -2350 0 0 {name=l875 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 4920 -2330 0 0 {name=l876 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 4920 -2310 0 0 {name=l877 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 4920 -2290 0 0 {name=l878 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 4920 -2270 0 0 {name=l879 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 4920 -2250 0 0 {name=l880 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 4920 -2230 0 0 {name=l881 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 4920 -2210 0 0 {name=l882 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 4920 -2170 0 0 {name=l883 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 4920 -2190 0 0 {name=l884 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 5050 -2850 1 0 {name=l918 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5070 -2850 1 0 {name=l919 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 5090 -2850 1 0 {name=l920 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 5110 -2850 1 0 {name=l921 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 5140 -2850 1 0 {name=l922 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5160 -2850 1 0 {name=l923 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 5610 -2540 0 0 {name=xbyte14 NF=2}
C {lab_wire.sym} 5440 -2790 0 0 {name=l924 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 5440 -2770 0 0 {name=l925 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 5440 -2750 0 0 {name=l926 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 5440 -2730 0 0 {name=l927 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 5440 -2710 0 0 {name=l928 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 5440 -2690 0 0 {name=l929 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 5440 -2670 0 0 {name=l930 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 5440 -2650 0 0 {name=l931 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 5440 -2630 0 0 {name=l932 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 5440 -2610 0 0 {name=l933 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 5440 -2590 0 0 {name=l934 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 5440 -2570 0 0 {name=l935 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 5440 -2550 0 0 {name=l936 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 5440 -2530 0 0 {name=l937 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 5440 -2510 0 0 {name=l938 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 5440 -2490 0 0 {name=l939 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 5440 -2470 0 0 {name=l940 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 5440 -2450 0 0 {name=l941 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 5440 -2430 0 0 {name=l942 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 5440 -2410 0 0 {name=l943 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 5440 -2390 0 0 {name=l944 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 5440 -2370 0 0 {name=l945 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 5440 -2350 0 0 {name=l946 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 5440 -2330 0 0 {name=l947 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 5440 -2310 0 0 {name=l948 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 5440 -2290 0 0 {name=l949 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 5440 -2270 0 0 {name=l950 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 5440 -2250 0 0 {name=l951 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 5440 -2230 0 0 {name=l952 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 5440 -2210 0 0 {name=l953 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 5440 -2170 0 0 {name=l954 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 5440 -2190 0 0 {name=l955 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 5570 -2850 1 0 {name=l989 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5590 -2850 1 0 {name=l990 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 5610 -2850 1 0 {name=l991 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 5630 -2850 1 0 {name=l992 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 5660 -2850 1 0 {name=l993 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5680 -2850 1 0 {name=l994 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 6150 -2540 0 0 {name=xbyte15 NF=2}
C {lab_wire.sym} 5980 -2790 0 0 {name=l995 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 5980 -2770 0 0 {name=l996 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 5980 -2750 0 0 {name=l997 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 5980 -2730 0 0 {name=l998 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 5980 -2710 0 0 {name=l999 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 5980 -2690 0 0 {name=l1000 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 5980 -2670 0 0 {name=l1001 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 5980 -2650 0 0 {name=l1002 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 5980 -2630 0 0 {name=l1003 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 5980 -2610 0 0 {name=l1004 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 5980 -2590 0 0 {name=l1005 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 5980 -2570 0 0 {name=l1006 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 5980 -2550 0 0 {name=l1007 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 5980 -2530 0 0 {name=l1008 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 5980 -2510 0 0 {name=l1009 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 5980 -2490 0 0 {name=l1010 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 5980 -2470 0 0 {name=l1011 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 5980 -2450 0 0 {name=l1012 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 5980 -2430 0 0 {name=l1013 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 5980 -2410 0 0 {name=l1014 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 5980 -2390 0 0 {name=l1015 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 5980 -2370 0 0 {name=l1016 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 5980 -2350 0 0 {name=l1017 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 5980 -2330 0 0 {name=l1018 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 5980 -2310 0 0 {name=l1019 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 5980 -2290 0 0 {name=l1020 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 5980 -2270 0 0 {name=l1021 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 5980 -2250 0 0 {name=l1022 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 5980 -2230 0 0 {name=l1023 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 5980 -2210 0 0 {name=l1024 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 5980 -2170 0 0 {name=l1025 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 5980 -2190 0 0 {name=l1026 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 6110 -2850 1 0 {name=l1060 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 6130 -2850 1 0 {name=l1061 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 6150 -2850 1 0 {name=l1062 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 6170 -2850 1 0 {name=l1063 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 6200 -2850 1 0 {name=l1064 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 6220 -2850 1 0 {name=l1065 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 6670 -2540 0 0 {name=xbyte16 NF=2}
C {lab_wire.sym} 6500 -2790 0 0 {name=l1066 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 6500 -2770 0 0 {name=l1067 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 6500 -2750 0 0 {name=l1068 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 6500 -2730 0 0 {name=l1069 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 6500 -2710 0 0 {name=l1070 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 6500 -2690 0 0 {name=l1071 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 6500 -2670 0 0 {name=l1072 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 6500 -2650 0 0 {name=l1073 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 6500 -2630 0 0 {name=l1074 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 6500 -2610 0 0 {name=l1075 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 6500 -2590 0 0 {name=l1076 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 6500 -2570 0 0 {name=l1077 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 6500 -2550 0 0 {name=l1078 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 6500 -2530 0 0 {name=l1079 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 6500 -2510 0 0 {name=l1080 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 6500 -2490 0 0 {name=l1081 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 6500 -2470 0 0 {name=l1082 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 6500 -2450 0 0 {name=l1083 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 6500 -2430 0 0 {name=l1084 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 6500 -2410 0 0 {name=l1085 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 6500 -2390 0 0 {name=l1086 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 6500 -2370 0 0 {name=l1087 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 6500 -2350 0 0 {name=l1088 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 6500 -2330 0 0 {name=l1089 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 6500 -2310 0 0 {name=l1090 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 6500 -2290 0 0 {name=l1091 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 6500 -2270 0 0 {name=l1092 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 6500 -2250 0 0 {name=l1093 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 6500 -2230 0 0 {name=l1094 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 6500 -2210 0 0 {name=l1095 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 6500 -2170 0 0 {name=l1096 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 6500 -2190 0 0 {name=l1097 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 6630 -2850 1 0 {name=l1131 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 6650 -2850 1 0 {name=l1132 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 6670 -2850 1 0 {name=l1133 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 6690 -2850 1 0 {name=l1134 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 6720 -2850 1 0 {name=l1135 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 6740 -2850 1 0 {name=l1136 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 3000 -1590 0 0 {name=xbyte17 NF=2}
C {lab_wire.sym} 2830 -1840 0 0 {name=l1137 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 2830 -1820 0 0 {name=l1138 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 2830 -1800 0 0 {name=l1139 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 2830 -1780 0 0 {name=l1140 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 2830 -1760 0 0 {name=l1141 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 2830 -1740 0 0 {name=l1142 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 2830 -1720 0 0 {name=l1143 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 2830 -1700 0 0 {name=l1144 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 2830 -1680 0 0 {name=l1145 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 2830 -1660 0 0 {name=l1146 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 2830 -1640 0 0 {name=l1147 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 2830 -1620 0 0 {name=l1148 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 2830 -1600 0 0 {name=l1149 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 2830 -1580 0 0 {name=l1150 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 2830 -1560 0 0 {name=l1151 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 2830 -1540 0 0 {name=l1152 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 2830 -1520 0 0 {name=l1153 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 2830 -1500 0 0 {name=l1154 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2830 -1480 0 0 {name=l1155 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2830 -1460 0 0 {name=l1156 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2830 -1440 0 0 {name=l1157 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2830 -1420 0 0 {name=l1158 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2830 -1400 0 0 {name=l1159 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2830 -1380 0 0 {name=l1160 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2830 -1360 0 0 {name=l1161 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2830 -1340 0 0 {name=l1162 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2830 -1320 0 0 {name=l1163 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2830 -1300 0 0 {name=l1164 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2830 -1280 0 0 {name=l1165 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2830 -1260 0 0 {name=l1166 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2830 -1220 0 0 {name=l1167 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2830 -1240 0 0 {name=l1168 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2960 -1900 1 0 {name=l1202 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 2980 -1900 1 0 {name=l1203 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 3000 -1900 1 0 {name=l1204 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 3020 -1900 1 0 {name=l1205 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 3050 -1900 1 0 {name=l1206 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3070 -1900 1 0 {name=l1207 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 3520 -1590 0 0 {name=xbyte18 NF=2}
C {lab_wire.sym} 3350 -1840 0 0 {name=l1208 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 3350 -1820 0 0 {name=l1209 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 3350 -1800 0 0 {name=l1210 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 3350 -1780 0 0 {name=l1211 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 3350 -1760 0 0 {name=l1212 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 3350 -1740 0 0 {name=l1213 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 3350 -1720 0 0 {name=l1214 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 3350 -1700 0 0 {name=l1215 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 3350 -1680 0 0 {name=l1216 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 3350 -1660 0 0 {name=l1217 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 3350 -1640 0 0 {name=l1218 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 3350 -1620 0 0 {name=l1219 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 3350 -1600 0 0 {name=l1220 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 3350 -1580 0 0 {name=l1221 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 3350 -1560 0 0 {name=l1222 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 3350 -1540 0 0 {name=l1223 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 3350 -1520 0 0 {name=l1224 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 3350 -1500 0 0 {name=l1225 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3350 -1480 0 0 {name=l1226 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3350 -1460 0 0 {name=l1227 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3350 -1440 0 0 {name=l1228 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3350 -1420 0 0 {name=l1229 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3350 -1400 0 0 {name=l1230 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3350 -1380 0 0 {name=l1231 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3350 -1360 0 0 {name=l1232 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3350 -1340 0 0 {name=l1233 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3350 -1320 0 0 {name=l1234 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3350 -1300 0 0 {name=l1235 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3350 -1280 0 0 {name=l1236 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3350 -1260 0 0 {name=l1237 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3350 -1220 0 0 {name=l1238 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3350 -1240 0 0 {name=l1239 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3480 -1900 1 0 {name=l1273 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 3500 -1900 1 0 {name=l1274 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 3520 -1900 1 0 {name=l1275 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 3540 -1900 1 0 {name=l1276 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 3570 -1900 1 0 {name=l1277 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3590 -1900 1 0 {name=l1278 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 4060 -1590 0 0 {name=xbyte19 NF=2}
C {lab_wire.sym} 3890 -1840 0 0 {name=l1279 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 3890 -1820 0 0 {name=l1280 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 3890 -1800 0 0 {name=l1281 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 3890 -1780 0 0 {name=l1282 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 3890 -1760 0 0 {name=l1283 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 3890 -1740 0 0 {name=l1284 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 3890 -1720 0 0 {name=l1285 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 3890 -1700 0 0 {name=l1286 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 3890 -1680 0 0 {name=l1287 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 3890 -1660 0 0 {name=l1288 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 3890 -1640 0 0 {name=l1289 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 3890 -1620 0 0 {name=l1290 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 3890 -1600 0 0 {name=l1291 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 3890 -1580 0 0 {name=l1292 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 3890 -1560 0 0 {name=l1293 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 3890 -1540 0 0 {name=l1294 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 3890 -1520 0 0 {name=l1295 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 3890 -1500 0 0 {name=l1296 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3890 -1480 0 0 {name=l1297 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3890 -1460 0 0 {name=l1298 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3890 -1440 0 0 {name=l1299 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3890 -1420 0 0 {name=l1300 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3890 -1400 0 0 {name=l1301 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3890 -1380 0 0 {name=l1302 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3890 -1360 0 0 {name=l1303 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3890 -1340 0 0 {name=l1304 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3890 -1320 0 0 {name=l1305 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3890 -1300 0 0 {name=l1306 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3890 -1280 0 0 {name=l1307 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3890 -1260 0 0 {name=l1308 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3890 -1220 0 0 {name=l1309 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3890 -1240 0 0 {name=l1310 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 4020 -1900 1 0 {name=l1344 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 4040 -1900 1 0 {name=l1345 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 4060 -1900 1 0 {name=l1346 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 4080 -1900 1 0 {name=l1347 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 4110 -1900 1 0 {name=l1348 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4130 -1900 1 0 {name=l1349 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 4580 -1590 0 0 {name=xbyte20 NF=2}
C {lab_wire.sym} 4410 -1840 0 0 {name=l1350 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 4410 -1820 0 0 {name=l1351 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 4410 -1800 0 0 {name=l1352 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 4410 -1780 0 0 {name=l1353 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 4410 -1760 0 0 {name=l1354 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 4410 -1740 0 0 {name=l1355 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 4410 -1720 0 0 {name=l1356 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 4410 -1700 0 0 {name=l1357 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 4410 -1680 0 0 {name=l1358 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 4410 -1660 0 0 {name=l1359 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 4410 -1640 0 0 {name=l1360 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 4410 -1620 0 0 {name=l1361 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 4410 -1600 0 0 {name=l1362 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 4410 -1580 0 0 {name=l1363 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 4410 -1560 0 0 {name=l1364 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 4410 -1540 0 0 {name=l1365 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 4410 -1520 0 0 {name=l1366 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 4410 -1500 0 0 {name=l1367 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 4410 -1480 0 0 {name=l1368 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 4410 -1460 0 0 {name=l1369 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 4410 -1440 0 0 {name=l1370 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 4410 -1420 0 0 {name=l1371 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 4410 -1400 0 0 {name=l1372 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 4410 -1380 0 0 {name=l1373 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 4410 -1360 0 0 {name=l1374 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 4410 -1340 0 0 {name=l1375 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 4410 -1320 0 0 {name=l1376 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 4410 -1300 0 0 {name=l1377 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 4410 -1280 0 0 {name=l1378 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 4410 -1260 0 0 {name=l1379 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 4410 -1220 0 0 {name=l1380 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 4410 -1240 0 0 {name=l1381 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 4540 -1900 1 0 {name=l1415 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 4560 -1900 1 0 {name=l1416 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 4580 -1900 1 0 {name=l1417 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 4600 -1900 1 0 {name=l1418 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 4630 -1900 1 0 {name=l1419 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4650 -1900 1 0 {name=l1420 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 5100 -1590 0 0 {name=xbyte21 NF=2}
C {lab_wire.sym} 4930 -1840 0 0 {name=l1421 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 4930 -1820 0 0 {name=l1422 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 4930 -1800 0 0 {name=l1423 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 4930 -1780 0 0 {name=l1424 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 4930 -1760 0 0 {name=l1425 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 4930 -1740 0 0 {name=l1426 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 4930 -1720 0 0 {name=l1427 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 4930 -1700 0 0 {name=l1428 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 4930 -1680 0 0 {name=l1429 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 4930 -1660 0 0 {name=l1430 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 4930 -1640 0 0 {name=l1431 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 4930 -1620 0 0 {name=l1432 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 4930 -1600 0 0 {name=l1433 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 4930 -1580 0 0 {name=l1434 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 4930 -1560 0 0 {name=l1435 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 4930 -1540 0 0 {name=l1436 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 4930 -1520 0 0 {name=l1437 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 4930 -1500 0 0 {name=l1438 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 4930 -1480 0 0 {name=l1439 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 4930 -1460 0 0 {name=l1440 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 4930 -1440 0 0 {name=l1441 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 4930 -1420 0 0 {name=l1442 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 4930 -1400 0 0 {name=l1443 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 4930 -1380 0 0 {name=l1444 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 4930 -1360 0 0 {name=l1445 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 4930 -1340 0 0 {name=l1446 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 4930 -1320 0 0 {name=l1447 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 4930 -1300 0 0 {name=l1448 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 4930 -1280 0 0 {name=l1449 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 4930 -1260 0 0 {name=l1450 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 4930 -1220 0 0 {name=l1451 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 4930 -1240 0 0 {name=l1452 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 5060 -1900 1 0 {name=l1486 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5080 -1900 1 0 {name=l1487 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 5100 -1900 1 0 {name=l1488 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 5120 -1900 1 0 {name=l1489 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 5150 -1900 1 0 {name=l1490 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5170 -1900 1 0 {name=l1491 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 5620 -1590 0 0 {name=xbyte22 NF=2}
C {lab_wire.sym} 5450 -1840 0 0 {name=l1492 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 5450 -1820 0 0 {name=l1493 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 5450 -1800 0 0 {name=l1494 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 5450 -1780 0 0 {name=l1495 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 5450 -1760 0 0 {name=l1496 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 5450 -1740 0 0 {name=l1497 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 5450 -1720 0 0 {name=l1498 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 5450 -1700 0 0 {name=l1499 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 5450 -1680 0 0 {name=l1500 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 5450 -1660 0 0 {name=l1501 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 5450 -1640 0 0 {name=l1502 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 5450 -1620 0 0 {name=l1503 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 5450 -1600 0 0 {name=l1504 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 5450 -1580 0 0 {name=l1505 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 5450 -1560 0 0 {name=l1506 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 5450 -1540 0 0 {name=l1507 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 5450 -1520 0 0 {name=l1508 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 5450 -1500 0 0 {name=l1509 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 5450 -1480 0 0 {name=l1510 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 5450 -1460 0 0 {name=l1511 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 5450 -1440 0 0 {name=l1512 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 5450 -1420 0 0 {name=l1513 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 5450 -1400 0 0 {name=l1514 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 5450 -1380 0 0 {name=l1515 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 5450 -1360 0 0 {name=l1516 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 5450 -1340 0 0 {name=l1517 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 5450 -1320 0 0 {name=l1518 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 5450 -1300 0 0 {name=l1519 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 5450 -1280 0 0 {name=l1520 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 5450 -1260 0 0 {name=l1521 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 5450 -1220 0 0 {name=l1522 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 5450 -1240 0 0 {name=l1523 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 5580 -1900 1 0 {name=l1557 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5600 -1900 1 0 {name=l1558 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 5620 -1900 1 0 {name=l1559 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 5640 -1900 1 0 {name=l1560 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 5670 -1900 1 0 {name=l1561 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5690 -1900 1 0 {name=l1562 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 6160 -1590 0 0 {name=xbyte23 NF=2}
C {lab_wire.sym} 5990 -1840 0 0 {name=l1563 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 5990 -1820 0 0 {name=l1564 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 5990 -1800 0 0 {name=l1565 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 5990 -1780 0 0 {name=l1566 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 5990 -1760 0 0 {name=l1567 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 5990 -1740 0 0 {name=l1568 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 5990 -1720 0 0 {name=l1569 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 5990 -1700 0 0 {name=l1570 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 5990 -1680 0 0 {name=l1571 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 5990 -1660 0 0 {name=l1572 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 5990 -1640 0 0 {name=l1573 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 5990 -1620 0 0 {name=l1574 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 5990 -1600 0 0 {name=l1575 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 5990 -1580 0 0 {name=l1576 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 5990 -1560 0 0 {name=l1577 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 5990 -1540 0 0 {name=l1578 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 5990 -1520 0 0 {name=l1579 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 5990 -1500 0 0 {name=l1580 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 5990 -1480 0 0 {name=l1581 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 5990 -1460 0 0 {name=l1582 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 5990 -1440 0 0 {name=l1583 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 5990 -1420 0 0 {name=l1584 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 5990 -1400 0 0 {name=l1585 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 5990 -1380 0 0 {name=l1586 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 5990 -1360 0 0 {name=l1587 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 5990 -1340 0 0 {name=l1588 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 5990 -1320 0 0 {name=l1589 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 5990 -1300 0 0 {name=l1590 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 5990 -1280 0 0 {name=l1591 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 5990 -1260 0 0 {name=l1592 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 5990 -1220 0 0 {name=l1593 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 5990 -1240 0 0 {name=l1594 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 6120 -1900 1 0 {name=l1628 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 6140 -1900 1 0 {name=l1629 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 6160 -1900 1 0 {name=l1630 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 6180 -1900 1 0 {name=l1631 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 6210 -1900 1 0 {name=l1632 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 6230 -1900 1 0 {name=l1633 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 6680 -1590 0 0 {name=xbyte24 NF=2}
C {lab_wire.sym} 6510 -1840 0 0 {name=l1634 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 6510 -1820 0 0 {name=l1635 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 6510 -1800 0 0 {name=l1636 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 6510 -1780 0 0 {name=l1637 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 6510 -1760 0 0 {name=l1638 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 6510 -1740 0 0 {name=l1639 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 6510 -1720 0 0 {name=l1640 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 6510 -1700 0 0 {name=l1641 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 6510 -1680 0 0 {name=l1642 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 6510 -1660 0 0 {name=l1643 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 6510 -1640 0 0 {name=l1644 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 6510 -1620 0 0 {name=l1645 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 6510 -1600 0 0 {name=l1646 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 6510 -1580 0 0 {name=l1647 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 6510 -1560 0 0 {name=l1648 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 6510 -1540 0 0 {name=l1649 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 6510 -1520 0 0 {name=l1650 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 6510 -1500 0 0 {name=l1651 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 6510 -1480 0 0 {name=l1652 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 6510 -1460 0 0 {name=l1653 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 6510 -1440 0 0 {name=l1654 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 6510 -1420 0 0 {name=l1655 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 6510 -1400 0 0 {name=l1656 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 6510 -1380 0 0 {name=l1657 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 6510 -1360 0 0 {name=l1658 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 6510 -1340 0 0 {name=l1659 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 6510 -1320 0 0 {name=l1660 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 6510 -1300 0 0 {name=l1661 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 6510 -1280 0 0 {name=l1662 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 6510 -1260 0 0 {name=l1663 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 6510 -1220 0 0 {name=l1664 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 6510 -1240 0 0 {name=l1665 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 6640 -1900 1 0 {name=l1699 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 6660 -1900 1 0 {name=l1700 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 6680 -1900 1 0 {name=l1701 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 6700 -1900 1 0 {name=l1702 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 6730 -1900 1 0 {name=l1703 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 6750 -1900 1 0 {name=l1704 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 3000 -690 0 0 {name=xbyte25 NF=2}
C {lab_wire.sym} 2830 -940 0 0 {name=l1705 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 2830 -920 0 0 {name=l1706 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 2830 -900 0 0 {name=l1707 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 2830 -880 0 0 {name=l1708 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 2830 -860 0 0 {name=l1709 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 2830 -840 0 0 {name=l1710 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 2830 -820 0 0 {name=l1711 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 2830 -800 0 0 {name=l1712 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 2830 -780 0 0 {name=l1713 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 2830 -760 0 0 {name=l1714 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 2830 -740 0 0 {name=l1715 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 2830 -720 0 0 {name=l1716 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 2830 -700 0 0 {name=l1717 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 2830 -680 0 0 {name=l1718 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 2830 -660 0 0 {name=l1719 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 2830 -640 0 0 {name=l1720 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 2830 -620 0 0 {name=l1721 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 2830 -600 0 0 {name=l1722 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 2830 -580 0 0 {name=l1723 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2830 -560 0 0 {name=l1724 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 2830 -540 0 0 {name=l1725 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 2830 -520 0 0 {name=l1726 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 2830 -500 0 0 {name=l1727 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2830 -480 0 0 {name=l1728 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 2830 -460 0 0 {name=l1729 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 2830 -440 0 0 {name=l1730 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 2830 -420 0 0 {name=l1731 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2830 -400 0 0 {name=l1732 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 2830 -380 0 0 {name=l1733 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 2830 -360 0 0 {name=l1734 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 2830 -320 0 0 {name=l1735 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 2830 -340 0 0 {name=l1736 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2960 -1000 1 0 {name=l1770 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 2980 -1000 1 0 {name=l1771 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 3000 -1000 1 0 {name=l1772 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 3020 -1000 1 0 {name=l1773 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 3050 -1000 1 0 {name=l1774 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3070 -1000 1 0 {name=l1775 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 3520 -690 0 0 {name=xbyte26 NF=2}
C {lab_wire.sym} 3350 -940 0 0 {name=l1776 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 3350 -920 0 0 {name=l1777 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 3350 -900 0 0 {name=l1778 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 3350 -880 0 0 {name=l1779 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 3350 -860 0 0 {name=l1780 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 3350 -840 0 0 {name=l1781 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 3350 -820 0 0 {name=l1782 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 3350 -800 0 0 {name=l1783 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 3350 -780 0 0 {name=l1784 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 3350 -760 0 0 {name=l1785 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 3350 -740 0 0 {name=l1786 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 3350 -720 0 0 {name=l1787 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 3350 -700 0 0 {name=l1788 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 3350 -680 0 0 {name=l1789 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 3350 -660 0 0 {name=l1790 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 3350 -640 0 0 {name=l1791 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 3350 -620 0 0 {name=l1792 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 3350 -600 0 0 {name=l1793 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3350 -580 0 0 {name=l1794 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3350 -560 0 0 {name=l1795 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3350 -540 0 0 {name=l1796 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3350 -520 0 0 {name=l1797 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3350 -500 0 0 {name=l1798 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3350 -480 0 0 {name=l1799 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3350 -460 0 0 {name=l1800 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3350 -440 0 0 {name=l1801 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3350 -420 0 0 {name=l1802 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3350 -400 0 0 {name=l1803 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3350 -380 0 0 {name=l1804 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3350 -360 0 0 {name=l1805 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3350 -320 0 0 {name=l1806 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3350 -340 0 0 {name=l1807 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 3480 -1000 1 0 {name=l1841 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 3500 -1000 1 0 {name=l1842 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 3520 -1000 1 0 {name=l1843 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 3540 -1000 1 0 {name=l1844 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 3570 -1000 1 0 {name=l1845 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3590 -1000 1 0 {name=l1846 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 4060 -690 0 0 {name=xbyte27 NF=2}
C {lab_wire.sym} 3890 -940 0 0 {name=l1847 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 3890 -920 0 0 {name=l1848 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 3890 -900 0 0 {name=l1849 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 3890 -880 0 0 {name=l1850 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 3890 -860 0 0 {name=l1851 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 3890 -840 0 0 {name=l1852 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 3890 -820 0 0 {name=l1853 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 3890 -800 0 0 {name=l1854 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 3890 -780 0 0 {name=l1855 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 3890 -760 0 0 {name=l1856 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 3890 -740 0 0 {name=l1857 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 3890 -720 0 0 {name=l1858 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 3890 -700 0 0 {name=l1859 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 3890 -680 0 0 {name=l1860 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 3890 -660 0 0 {name=l1861 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 3890 -640 0 0 {name=l1862 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 3890 -620 0 0 {name=l1863 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 3890 -600 0 0 {name=l1864 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 3890 -580 0 0 {name=l1865 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 3890 -560 0 0 {name=l1866 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 3890 -540 0 0 {name=l1867 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 3890 -520 0 0 {name=l1868 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 3890 -500 0 0 {name=l1869 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 3890 -480 0 0 {name=l1870 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 3890 -460 0 0 {name=l1871 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 3890 -440 0 0 {name=l1872 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 3890 -420 0 0 {name=l1873 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 3890 -400 0 0 {name=l1874 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 3890 -380 0 0 {name=l1875 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 3890 -360 0 0 {name=l1876 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 3890 -320 0 0 {name=l1877 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 3890 -340 0 0 {name=l1878 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 4020 -1000 1 0 {name=l1912 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 4040 -1000 1 0 {name=l1913 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 4060 -1000 1 0 {name=l1914 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 4080 -1000 1 0 {name=l1915 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 4110 -1000 1 0 {name=l1916 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4130 -1000 1 0 {name=l1917 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 4580 -690 0 0 {name=xbyte28 NF=2}
C {lab_wire.sym} 4410 -940 0 0 {name=l1918 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 4410 -920 0 0 {name=l1919 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 4410 -900 0 0 {name=l1920 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 4410 -880 0 0 {name=l1921 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 4410 -860 0 0 {name=l1922 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 4410 -840 0 0 {name=l1923 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 4410 -820 0 0 {name=l1924 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 4410 -800 0 0 {name=l1925 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 4410 -780 0 0 {name=l1926 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 4410 -760 0 0 {name=l1927 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 4410 -740 0 0 {name=l1928 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 4410 -720 0 0 {name=l1929 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 4410 -700 0 0 {name=l1930 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 4410 -680 0 0 {name=l1931 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 4410 -660 0 0 {name=l1932 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 4410 -640 0 0 {name=l1933 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 4410 -620 0 0 {name=l1934 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 4410 -600 0 0 {name=l1935 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 4410 -580 0 0 {name=l1936 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 4410 -560 0 0 {name=l1937 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 4410 -540 0 0 {name=l1938 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 4410 -520 0 0 {name=l1939 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 4410 -500 0 0 {name=l1940 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 4410 -480 0 0 {name=l1941 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 4410 -460 0 0 {name=l1942 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 4410 -440 0 0 {name=l1943 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 4410 -420 0 0 {name=l1944 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 4410 -400 0 0 {name=l1945 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 4410 -380 0 0 {name=l1946 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 4410 -360 0 0 {name=l1947 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 4410 -320 0 0 {name=l1948 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 4410 -340 0 0 {name=l1949 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 4540 -1000 1 0 {name=l1983 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 4560 -1000 1 0 {name=l1984 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 4580 -1000 1 0 {name=l1985 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 4600 -1000 1 0 {name=l1986 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 4630 -1000 1 0 {name=l1987 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4650 -1000 1 0 {name=l1988 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 5100 -690 0 0 {name=xbyte29 NF=2}
C {lab_wire.sym} 4930 -940 0 0 {name=l1989 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 4930 -920 0 0 {name=l1990 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 4930 -900 0 0 {name=l1991 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 4930 -880 0 0 {name=l1992 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 4930 -860 0 0 {name=l1993 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 4930 -840 0 0 {name=l1994 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 4930 -820 0 0 {name=l1995 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 4930 -800 0 0 {name=l1996 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 4930 -780 0 0 {name=l1997 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 4930 -760 0 0 {name=l1998 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 4930 -740 0 0 {name=l1999 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 4930 -720 0 0 {name=l2000 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 4930 -700 0 0 {name=l2001 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 4930 -680 0 0 {name=l2002 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 4930 -660 0 0 {name=l2003 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 4930 -640 0 0 {name=l2004 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 4930 -620 0 0 {name=l2005 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 4930 -600 0 0 {name=l2006 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 4930 -580 0 0 {name=l2007 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 4930 -560 0 0 {name=l2008 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 4930 -540 0 0 {name=l2009 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 4930 -520 0 0 {name=l2010 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 4930 -500 0 0 {name=l2011 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 4930 -480 0 0 {name=l2012 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 4930 -460 0 0 {name=l2013 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 4930 -440 0 0 {name=l2014 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 4930 -420 0 0 {name=l2015 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 4930 -400 0 0 {name=l2016 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 4930 -380 0 0 {name=l2017 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 4930 -360 0 0 {name=l2018 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 4930 -320 0 0 {name=l2019 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 4930 -340 0 0 {name=l2020 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 5060 -1000 1 0 {name=l2054 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5080 -1000 1 0 {name=l2055 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 5100 -1000 1 0 {name=l2056 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 5120 -1000 1 0 {name=l2057 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 5150 -1000 1 0 {name=l2058 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5170 -1000 1 0 {name=l2059 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 5620 -690 0 0 {name=xbyte30 NF=2}
C {lab_wire.sym} 5450 -940 0 0 {name=l2060 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 5450 -920 0 0 {name=l2061 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 5450 -900 0 0 {name=l2062 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 5450 -880 0 0 {name=l2063 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 5450 -860 0 0 {name=l2064 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 5450 -840 0 0 {name=l2065 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 5450 -820 0 0 {name=l2066 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 5450 -800 0 0 {name=l2067 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 5450 -780 0 0 {name=l2068 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 5450 -760 0 0 {name=l2069 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 5450 -740 0 0 {name=l2070 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 5450 -720 0 0 {name=l2071 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 5450 -700 0 0 {name=l2072 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 5450 -680 0 0 {name=l2073 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 5450 -660 0 0 {name=l2074 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 5450 -640 0 0 {name=l2075 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 5450 -620 0 0 {name=l2076 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 5450 -600 0 0 {name=l2077 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 5450 -580 0 0 {name=l2078 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 5450 -560 0 0 {name=l2079 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 5450 -540 0 0 {name=l2080 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 5450 -520 0 0 {name=l2081 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 5450 -500 0 0 {name=l2082 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 5450 -480 0 0 {name=l2083 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 5450 -460 0 0 {name=l2084 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 5450 -440 0 0 {name=l2085 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 5450 -420 0 0 {name=l2086 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 5450 -400 0 0 {name=l2087 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 5450 -380 0 0 {name=l2088 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 5450 -360 0 0 {name=l2089 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 5450 -320 0 0 {name=l2090 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 5450 -340 0 0 {name=l2091 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 5580 -1000 1 0 {name=l2125 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5600 -1000 1 0 {name=l2126 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 5620 -1000 1 0 {name=l2127 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 5640 -1000 1 0 {name=l2128 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 5670 -1000 1 0 {name=l2129 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5690 -1000 1 0 {name=l2130 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 6160 -690 0 0 {name=xbyte31 NF=2}
C {lab_wire.sym} 5990 -940 0 0 {name=l2131 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 5990 -920 0 0 {name=l2132 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 5990 -900 0 0 {name=l2133 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 5990 -880 0 0 {name=l2134 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 5990 -860 0 0 {name=l2135 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 5990 -840 0 0 {name=l2136 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 5990 -820 0 0 {name=l2137 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 5990 -800 0 0 {name=l2138 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 5990 -780 0 0 {name=l2139 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 5990 -760 0 0 {name=l2140 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 5990 -740 0 0 {name=l2141 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 5990 -720 0 0 {name=l2142 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 5990 -700 0 0 {name=l2143 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 5990 -680 0 0 {name=l2144 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 5990 -660 0 0 {name=l2145 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 5990 -640 0 0 {name=l2146 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 5990 -620 0 0 {name=l2147 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 5990 -600 0 0 {name=l2148 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 5990 -580 0 0 {name=l2149 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 5990 -560 0 0 {name=l2150 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 5990 -540 0 0 {name=l2151 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 5990 -520 0 0 {name=l2152 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 5990 -500 0 0 {name=l2153 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 5990 -480 0 0 {name=l2154 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 5990 -460 0 0 {name=l2155 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 5990 -440 0 0 {name=l2156 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 5990 -420 0 0 {name=l2157 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 5990 -400 0 0 {name=l2158 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 5990 -380 0 0 {name=l2159 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 5990 -360 0 0 {name=l2160 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 5990 -320 0 0 {name=l2161 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 5990 -340 0 0 {name=l2162 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 6120 -1000 1 0 {name=l2196 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 6140 -1000 1 0 {name=l2197 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 6160 -1000 1 0 {name=l2198 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 6180 -1000 1 0 {name=l2199 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 6210 -1000 1 0 {name=l2200 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 6230 -1000 1 0 {name=l2201 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/word.sym} 6680 -690 0 0 {name=xbyte32 NF=2}
C {lab_wire.sym} 6510 -940 0 0 {name=l2202 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 6510 -920 0 0 {name=l2203 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 6510 -900 0 0 {name=l2204 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 6510 -880 0 0 {name=l2205 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 6510 -860 0 0 {name=l2206 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 6510 -840 0 0 {name=l2207 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 6510 -820 0 0 {name=l2208 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 6510 -800 0 0 {name=l2209 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 6510 -780 0 0 {name=l2210 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 6510 -760 0 0 {name=l2211 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 6510 -740 0 0 {name=l2212 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 6510 -720 0 0 {name=l2213 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 6510 -700 0 0 {name=l2214 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 6510 -680 0 0 {name=l2215 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 6510 -660 0 0 {name=l2216 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 6510 -640 0 0 {name=l2217 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 6510 -620 0 0 {name=l2218 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 6510 -600 0 0 {name=l2219 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 6510 -580 0 0 {name=l2220 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 6510 -560 0 0 {name=l2221 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 6510 -540 0 0 {name=l2222 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 6510 -520 0 0 {name=l2223 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 6510 -500 0 0 {name=l2224 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 6510 -480 0 0 {name=l2225 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 6510 -460 0 0 {name=l2226 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 6510 -440 0 0 {name=l2227 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 6510 -420 0 0 {name=l2228 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 6510 -400 0 0 {name=l2229 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 6510 -380 0 0 {name=l2230 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 6510 -360 0 0 {name=l2231 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 6510 -320 0 0 {name=l2232 sig_type=std_logic lab=Di[31]}
C {lab_wire.sym} 6510 -340 0 0 {name=l2233 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 6640 -1000 1 0 {name=l2267 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 6660 -1000 1 0 {name=l2268 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 6680 -1000 1 0 {name=l2269 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 6700 -1000 1 0 {name=l2270 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 6730 -1000 1 0 {name=l2271 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 6750 -1000 1 0 {name=l2272 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 6070 -3750 0 0 {name=l491 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 6590 -3750 0 0 {name=l562 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2910 -2850 0 0 {name=l633 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3430 -2850 0 0 {name=l704 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3970 -2850 0 0 {name=l775 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 4490 -2850 0 0 {name=l846 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 5010 -2850 0 0 {name=l917 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 5530 -2850 0 0 {name=l988 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 6070 -2850 0 0 {name=l1059 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 6590 -2850 0 0 {name=l1130 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 6600 -1900 0 0 {name=l1201 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 6080 -1900 0 0 {name=l1272 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 5540 -1900 0 0 {name=l1343 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 5020 -1900 0 0 {name=l1414 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 4500 -1900 0 0 {name=l1485 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3980 -1900 0 0 {name=l1556 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3440 -1900 0 0 {name=l1627 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2920 -1900 0 0 {name=l1698 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2920 -1000 0 0 {name=l1769 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3440 -1000 0 0 {name=l1840 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 3980 -1000 0 0 {name=l1911 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 4500 -1000 0 0 {name=l1982 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 5020 -1000 0 0 {name=l2053 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 5540 -1000 0 0 {name=l2124 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 6080 -1000 0 0 {name=l2195 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 6600 -1000 0 0 {name=l2266 sig_type=std_logic lab=CLK_buf}
C {xschem_lib/DFFRAM_full_custom/dec_2to4.sym} 1180 -3230 0 0 {name=x1 NF=2}
C {xschem_lib/DFFRAM_full_custom/dec_3to8.sym} 1610 -3610 0 0 {name=x_dec1 NF=2}
C {xschem_lib/DFFRAM_full_custom/dec_3to8.sym} 1610 -3360 0 0 {name=x_dec2 NF=2}
C {xschem_lib/DFFRAM_full_custom/dec_3to8.sym} 1610 -3110 0 0 {name=x_dec3 NF=2}
C {xschem_lib/DFFRAM_full_custom/dec_3to8.sym} 1610 -2850 0 0 {name=x_dec4 NF=2}
C {lab_wire.sym} 1090 -3270 0 0 {name=l2273 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1090 -3250 0 0 {name=l2274 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1510 -3670 0 0 {name=l2275 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1510 -3650 0 0 {name=l2276 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1510 -3420 0 0 {name=l2277 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1510 -3400 0 0 {name=l2278 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1510 -3170 0 0 {name=l2279 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1510 -3150 0 0 {name=l2280 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1510 -2910 0 0 {name=l2281 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1510 -2890 0 0 {name=l2282 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1100 -2530 0 0 {name=X_inv1 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1260 -2530 0 0 {name=X_inv2 NF=8}
C {lab_wire.sym} 1240 -2610 0 0 {name=l2283 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1240 -2530 0 0 {name=l2284 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1710 -3680 2 0 {name=l2285 sig_type=std_logic lab=Y0}
C {lab_wire.sym} 1710 -3660 2 0 {name=l2286 sig_type=std_logic lab=Y1}
C {lab_wire.sym} 1710 -3640 2 0 {name=l2287 sig_type=std_logic lab=Y2}
C {lab_wire.sym} 1710 -3620 2 0 {name=l2288 sig_type=std_logic lab=Y3}
C {lab_wire.sym} 1710 -3600 2 0 {name=l2289 sig_type=std_logic lab=Y4}
C {lab_wire.sym} 1710 -3580 2 0 {name=l2290 sig_type=std_logic lab=Y5}
C {lab_wire.sym} 1710 -3560 2 0 {name=l2291 sig_type=std_logic lab=Y6}
C {lab_wire.sym} 1710 -3540 2 0 {name=l2292 sig_type=std_logic lab=Y7}
C {lab_wire.sym} 1710 -3430 2 0 {name=l2293 sig_type=std_logic lab=Y8}
C {lab_wire.sym} 1710 -3410 2 0 {name=l2294 sig_type=std_logic lab=Y9}
C {lab_wire.sym} 1710 -3390 2 0 {name=l2295 sig_type=std_logic lab=Y10}
C {lab_wire.sym} 1710 -3370 2 0 {name=l2296 sig_type=std_logic lab=Y11}
C {lab_wire.sym} 1710 -3350 2 0 {name=l2297 sig_type=std_logic lab=Y12}
C {lab_wire.sym} 1710 -3330 2 0 {name=l2298 sig_type=std_logic lab=Y13}
C {lab_wire.sym} 1710 -3310 2 0 {name=l2299 sig_type=std_logic lab=Y14}
C {lab_wire.sym} 1710 -3290 2 0 {name=l2300 sig_type=std_logic lab=Y15}
C {lab_wire.sym} 1710 -3180 2 0 {name=l2301 sig_type=std_logic lab=Y16}
C {lab_wire.sym} 1710 -3160 2 0 {name=l2302 sig_type=std_logic lab=Y17}
C {lab_wire.sym} 1710 -3140 2 0 {name=l2303 sig_type=std_logic lab=Y18}
C {lab_wire.sym} 1710 -3120 2 0 {name=l2304 sig_type=std_logic lab=Y19}
C {lab_wire.sym} 1710 -3100 2 0 {name=l2305 sig_type=std_logic lab=Y20}
C {lab_wire.sym} 1710 -3080 2 0 {name=l2306 sig_type=std_logic lab=Y21}
C {lab_wire.sym} 1710 -3060 2 0 {name=l2307 sig_type=std_logic lab=Y22}
C {lab_wire.sym} 1710 -3040 2 0 {name=l2308 sig_type=std_logic lab=Y23}
C {lab_wire.sym} 1710 -2920 2 0 {name=l2309 sig_type=std_logic lab=Y24}
C {lab_wire.sym} 1710 -2900 2 0 {name=l2310 sig_type=std_logic lab=Y25}
C {lab_wire.sym} 1710 -2880 2 0 {name=l2311 sig_type=std_logic lab=Y26}
C {lab_wire.sym} 1710 -2860 2 0 {name=l2312 sig_type=std_logic lab=Y27}
C {lab_wire.sym} 1710 -2840 2 0 {name=l2313 sig_type=std_logic lab=Y28}
C {lab_wire.sym} 1710 -2820 2 0 {name=l2314 sig_type=std_logic lab=Y29}
C {lab_wire.sym} 1710 -2800 2 0 {name=l2315 sig_type=std_logic lab=Y30}
C {lab_wire.sym} 1710 -2780 2 0 {name=l2316 sig_type=std_logic lab=Y31}
C {lab_wire.sym} 1090 -2570 0 0 {name=l2317 sig_type=std_logic lab=Y0}
C {lab_wire.sym} 1420 -2570 0 0 {name=l2318 sig_type=std_logic lab=SEL[0]}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1460 -2530 0 0 {name=X_inv3 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1620 -2530 0 0 {name=X_inv4 NF=8}
C {lab_wire.sym} 1600 -2610 0 0 {name=l2319 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1600 -2530 0 0 {name=l2320 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1450 -2570 0 0 {name=l2321 sig_type=std_logic lab=Y1}
C {lab_wire.sym} 1780 -2570 0 0 {name=l2322 sig_type=std_logic lab=SEL1}
C {lab_wire.sym} 1980 -2610 0 0 {name=l2323 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1980 -2530 0 0 {name=l2324 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1830 -2570 0 0 {name=l2325 sig_type=std_logic lab=Y2}
C {lab_wire.sym} 2160 -2570 0 0 {name=l2326 sig_type=std_logic lab=SEL[2]}
C {lab_wire.sym} 2340 -2610 0 0 {name=l2327 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2340 -2530 0 0 {name=l2328 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2190 -2570 0 0 {name=l2329 sig_type=std_logic lab=Y3}
C {lab_wire.sym} 2520 -2570 0 0 {name=l2330 sig_type=std_logic lab=SEL[3]}
C {lab_wire.sym} 1240 -2440 0 0 {name=l2331 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1240 -2360 0 0 {name=l2332 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1090 -2400 0 0 {name=l2333 sig_type=std_logic lab=Y4}
C {lab_wire.sym} 1420 -2400 0 0 {name=l2334 sig_type=std_logic lab=SEL[4]}
C {lab_wire.sym} 1600 -2440 0 0 {name=l2335 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1600 -2360 0 0 {name=l2336 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1450 -2400 0 0 {name=l2337 sig_type=std_logic lab=Y5}
C {lab_wire.sym} 1780 -2400 0 0 {name=l2338 sig_type=std_logic lab=SEL[5]}
C {lab_wire.sym} 1980 -2440 0 0 {name=l2339 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1980 -2360 0 0 {name=l2340 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1830 -2400 0 0 {name=l2341 sig_type=std_logic lab=Y6}
C {lab_wire.sym} 2160 -2400 0 0 {name=l2342 sig_type=std_logic lab=SEL[6]}
C {lab_wire.sym} 2340 -2440 0 0 {name=l2343 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2340 -2360 0 0 {name=l2344 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2190 -2400 0 0 {name=l2345 sig_type=std_logic lab=Y7}
C {lab_wire.sym} 2520 -2400 0 0 {name=l2346 sig_type=std_logic lab=SEL[7]}
C {lab_wire.sym} 1230 -2270 0 0 {name=l2347 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1230 -2190 0 0 {name=l2348 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1080 -2230 0 0 {name=l2349 sig_type=std_logic lab=Y8}
C {lab_wire.sym} 1410 -2230 0 0 {name=l2350 sig_type=std_logic lab=SEL[8]}
C {lab_wire.sym} 1590 -2270 0 0 {name=l2351 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1590 -2190 0 0 {name=l2352 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1440 -2230 0 0 {name=l2353 sig_type=std_logic lab=Y9}
C {lab_wire.sym} 1770 -2230 0 0 {name=l2354 sig_type=std_logic lab=SEL[9]}
C {lab_wire.sym} 1970 -2270 0 0 {name=l2355 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1970 -2190 0 0 {name=l2356 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1820 -2230 0 0 {name=l2357 sig_type=std_logic lab=Y10}
C {lab_wire.sym} 2150 -2230 0 0 {name=l2358 sig_type=std_logic lab=SEL[10]}
C {lab_wire.sym} 2330 -2270 0 0 {name=l2359 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2330 -2190 0 0 {name=l2360 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2180 -2230 0 0 {name=l2361 sig_type=std_logic lab=Y11}
C {lab_wire.sym} 2510 -2230 0 0 {name=l2362 sig_type=std_logic lab=SEL[11]}
C {lab_wire.sym} 1230 -2100 0 0 {name=l2363 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1230 -2020 0 0 {name=l2364 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1080 -2060 0 0 {name=l2365 sig_type=std_logic lab=Y12}
C {lab_wire.sym} 1410 -2060 0 0 {name=l2366 sig_type=std_logic lab=SEL[12]}
C {lab_wire.sym} 1590 -2100 0 0 {name=l2367 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1590 -2020 0 0 {name=l2368 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1440 -2060 0 0 {name=l2369 sig_type=std_logic lab=Y13}
C {lab_wire.sym} 1770 -2060 0 0 {name=l2370 sig_type=std_logic lab=SEL[13]}
C {lab_wire.sym} 1970 -2100 0 0 {name=l2371 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1970 -2020 0 0 {name=l2372 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1820 -2060 0 0 {name=l2373 sig_type=std_logic lab=Y14}
C {lab_wire.sym} 2150 -2060 0 0 {name=l2374 sig_type=std_logic lab=SEL[14]}
C {lab_wire.sym} 2330 -2100 0 0 {name=l2375 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2330 -2020 0 0 {name=l2376 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2180 -2060 0 0 {name=l2377 sig_type=std_logic lab=Y15}
C {lab_wire.sym} 2510 -2060 0 0 {name=l2378 sig_type=std_logic lab=SEL[15]}
C {lab_wire.sym} 1240 -1930 0 0 {name=l2379 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1240 -1850 0 0 {name=l2380 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1090 -1890 0 0 {name=l2381 sig_type=std_logic lab=Y16}
C {lab_wire.sym} 1420 -1890 0 0 {name=l2382 sig_type=std_logic lab=SEL[16]}
C {lab_wire.sym} 1600 -1930 0 0 {name=l2383 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1600 -1850 0 0 {name=l2384 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1450 -1890 0 0 {name=l2385 sig_type=std_logic lab=Y17}
C {lab_wire.sym} 1780 -1890 0 0 {name=l2386 sig_type=std_logic lab=SEL[17]}
C {lab_wire.sym} 1980 -1930 0 0 {name=l2387 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1980 -1850 0 0 {name=l2388 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1830 -1890 0 0 {name=l2389 sig_type=std_logic lab=Y18}
C {lab_wire.sym} 2160 -1890 0 0 {name=l2390 sig_type=std_logic lab=SEL[18]}
C {lab_wire.sym} 2340 -1930 0 0 {name=l2391 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2340 -1850 0 0 {name=l2392 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2190 -1890 0 0 {name=l2393 sig_type=std_logic lab=Y19}
C {lab_wire.sym} 2520 -1890 0 0 {name=l2394 sig_type=std_logic lab=SEL[19]}
C {lab_wire.sym} 1240 -1760 0 0 {name=l2395 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1240 -1680 0 0 {name=l2396 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1090 -1720 0 0 {name=l2397 sig_type=std_logic lab=Y20}
C {lab_wire.sym} 1420 -1720 0 0 {name=l2398 sig_type=std_logic lab=SEL[20]}
C {lab_wire.sym} 1600 -1760 0 0 {name=l2399 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1600 -1680 0 0 {name=l2400 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1450 -1720 0 0 {name=l2401 sig_type=std_logic lab=Y21}
C {lab_wire.sym} 1780 -1720 0 0 {name=l2402 sig_type=std_logic lab=SEL[21]}
C {lab_wire.sym} 1980 -1760 0 0 {name=l2403 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1980 -1680 0 0 {name=l2404 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1830 -1720 0 0 {name=l2405 sig_type=std_logic lab=Y22}
C {lab_wire.sym} 2160 -1720 0 0 {name=l2406 sig_type=std_logic lab=SEL[22]}
C {lab_wire.sym} 2340 -1760 0 0 {name=l2407 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2340 -1680 0 0 {name=l2408 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2190 -1720 0 0 {name=l2409 sig_type=std_logic lab=Y23}
C {lab_wire.sym} 2520 -1720 0 0 {name=l2410 sig_type=std_logic lab=SEL[23]}
C {lab_wire.sym} 1240 -1590 0 0 {name=l2411 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1240 -1510 0 0 {name=l2412 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1090 -1550 0 0 {name=l2413 sig_type=std_logic lab=Y24}
C {lab_wire.sym} 1420 -1550 0 0 {name=l2414 sig_type=std_logic lab=SEL[24]}
C {lab_wire.sym} 1600 -1590 0 0 {name=l2415 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1600 -1510 0 0 {name=l2416 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1450 -1550 0 0 {name=l2417 sig_type=std_logic lab=Y25}
C {lab_wire.sym} 1780 -1550 0 0 {name=l2418 sig_type=std_logic lab=SEL[25]}
C {lab_wire.sym} 1980 -1590 0 0 {name=l2419 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1980 -1510 0 0 {name=l2420 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1830 -1550 0 0 {name=l2421 sig_type=std_logic lab=Y26}
C {lab_wire.sym} 2160 -1550 0 0 {name=l2422 sig_type=std_logic lab=SEL[26]}
C {lab_wire.sym} 2340 -1590 0 0 {name=l2423 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2340 -1510 0 0 {name=l2424 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2190 -1550 0 0 {name=l2425 sig_type=std_logic lab=Y27}
C {lab_wire.sym} 2520 -1550 0 0 {name=l2426 sig_type=std_logic lab=SEL[27]}
C {lab_wire.sym} 1240 -1420 0 0 {name=l2427 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1240 -1340 0 0 {name=l2428 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1090 -1380 0 0 {name=l2429 sig_type=std_logic lab=Y28}
C {lab_wire.sym} 1420 -1380 0 0 {name=l2430 sig_type=std_logic lab=SEL[28]}
C {lab_wire.sym} 1600 -1420 0 0 {name=l2431 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1600 -1340 0 0 {name=l2432 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1450 -1380 0 0 {name=l2433 sig_type=std_logic lab=Y29}
C {lab_wire.sym} 1780 -1380 0 0 {name=l2434 sig_type=std_logic lab=SEL[29]}
C {lab_wire.sym} 1980 -1420 0 0 {name=l2435 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1980 -1340 0 0 {name=l2436 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1830 -1380 0 0 {name=l2437 sig_type=std_logic lab=Y30}
C {lab_wire.sym} 2160 -1380 0 0 {name=l2438 sig_type=std_logic lab=SEL[30]}
C {lab_wire.sym} 2340 -1420 0 0 {name=l2439 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2340 -1340 0 0 {name=l2440 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2190 -1380 0 0 {name=l2441 sig_type=std_logic lab=Y31}
C {lab_wire.sym} 2520 -1380 0 0 {name=l2442 sig_type=std_logic lab=SEL[31]}
C {lab_wire.sym} 2930 -2850 1 0 {name=l2443 sig_type=std_logic lab=SEL[8]}
C {lab_wire.sym} 2930 -3750 1 0 {name=l2444 sig_type=std_logic lab=SEL[0]}
C {lab_wire.sym} 2940 -1900 1 0 {name=l2445 sig_type=std_logic lab=SEL[16]}
C {lab_wire.sym} 2940 -1000 1 0 {name=l2446 sig_type=std_logic lab=SEL[24]}
C {lab_wire.sym} 3470 -3750 1 0 {name=l2447 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 3470 -2850 1 0 {name=l2448 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 3450 -2850 1 0 {name=l2449 sig_type=std_logic lab=SEL[9]}
C {lab_wire.sym} 3450 -3750 1 0 {name=l2450 sig_type=std_logic lab=SEL1}
C {lab_wire.sym} 3460 -1900 1 0 {name=l2451 sig_type=std_logic lab=SEL[17]}
C {lab_wire.sym} 3460 -1000 1 0 {name=l2452 sig_type=std_logic lab=SEL[25]}
C {lab_wire.sym} 4010 -3750 1 0 {name=l2453 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 4010 -2850 1 0 {name=l2454 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 3990 -2850 1 0 {name=l2455 sig_type=std_logic lab=SEL[10]}
C {lab_wire.sym} 3990 -3750 1 0 {name=l2456 sig_type=std_logic lab=SEL[2]}
C {lab_wire.sym} 4000 -1900 1 0 {name=l2457 sig_type=std_logic lab=SEL[18]}
C {lab_wire.sym} 4000 -1000 1 0 {name=l2458 sig_type=std_logic lab=SEL[26]}
C {lab_wire.sym} 4530 -3750 1 0 {name=l2459 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 4530 -2850 1 0 {name=l2460 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 4510 -2850 1 0 {name=l2461 sig_type=std_logic lab=SEL[11]}
C {lab_wire.sym} 4510 -3750 1 0 {name=l2462 sig_type=std_logic lab=SEL[3]}
C {lab_wire.sym} 4520 -1900 1 0 {name=l2463 sig_type=std_logic lab=SEL[19]}
C {lab_wire.sym} 4520 -1000 1 0 {name=l2464 sig_type=std_logic lab=SEL[27]}
C {lab_wire.sym} 5050 -3750 1 0 {name=l2465 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5050 -2850 1 0 {name=l2466 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5030 -2850 1 0 {name=l2467 sig_type=std_logic lab=SEL[12]}
C {lab_wire.sym} 5030 -3750 1 0 {name=l2468 sig_type=std_logic lab=SEL[4]}
C {lab_wire.sym} 5040 -1900 1 0 {name=l2469 sig_type=std_logic lab=SEL[20]}
C {lab_wire.sym} 5040 -1000 1 0 {name=l2470 sig_type=std_logic lab=SEL[28]}
C {lab_wire.sym} 5570 -3750 1 0 {name=l2471 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5570 -2850 1 0 {name=l2472 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 5550 -2850 1 0 {name=l2473 sig_type=std_logic lab=SEL[13]}
C {lab_wire.sym} 5550 -3750 1 0 {name=l2474 sig_type=std_logic lab=SEL[5]}
C {lab_wire.sym} 5560 -1900 1 0 {name=l2475 sig_type=std_logic lab=SEL[21]}
C {lab_wire.sym} 5560 -1000 1 0 {name=l2476 sig_type=std_logic lab=SEL[29]}
C {lab_wire.sym} 6110 -3750 1 0 {name=l2477 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 6110 -2850 1 0 {name=l2478 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 6090 -2850 1 0 {name=l2479 sig_type=std_logic lab=SEL[14]}
C {lab_wire.sym} 6090 -3750 1 0 {name=l2480 sig_type=std_logic lab=SEL[6]}
C {lab_wire.sym} 6100 -1900 1 0 {name=l2481 sig_type=std_logic lab=SEL[22]}
C {lab_wire.sym} 6100 -1000 1 0 {name=l2482 sig_type=std_logic lab=SEL[30]}
C {lab_wire.sym} 6630 -3750 1 0 {name=l2483 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 6630 -2850 1 0 {name=l2484 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 6610 -2850 1 0 {name=l2485 sig_type=std_logic lab=SEL[15]}
C {lab_wire.sym} 6610 -3750 1 0 {name=l2486 sig_type=std_logic lab=SEL[7]}
C {lab_wire.sym} 6620 -1900 1 0 {name=l2487 sig_type=std_logic lab=SEL[23]}
C {lab_wire.sym} 6620 -1000 1 0 {name=l2488 sig_type=std_logic lab=SEL[31]}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1090 -3880 0 0 {name=X_inv65 NF=8}
C {lab_wire.sym} 1150 -3970 0 0 {name=l2489 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1150 -3870 2 0 {name=l2490 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 890 -3920 0 0 {name=l2491 sig_type=std_logic lab=CLK}
C {lab_wire.sym} 1640 -3920 2 0 {name=l2492 sig_type=std_logic lab=CLK_buf}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1920 -2990 0 0 {name=X_inv67 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2080 -2990 0 0 {name=X_inv68 NF=16}
C {lab_wire.sym} 2060 -3070 0 0 {name=l2493 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2060 -2990 0 0 {name=l2494 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1910 -3030 0 0 {name=l2495 sig_type=std_logic lab=WE3}
C {lab_wire.sym} 2240 -3030 0 0 {name=l2496 sig_type=std_logic lab=we3_buf}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1920 -3110 0 0 {name=X_inv69 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2080 -3110 0 0 {name=X_inv70 NF=16}
C {lab_wire.sym} 2060 -3190 0 0 {name=l2497 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2060 -3110 0 0 {name=l2498 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1910 -3150 0 0 {name=l2499 sig_type=std_logic lab=WE2}
C {lab_wire.sym} 2240 -3150 0 0 {name=l2500 sig_type=std_logic lab=we2_buf}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1920 -3240 0 0 {name=X_inv71 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2080 -3240 0 0 {name=X_inv72 NF=16}
C {lab_wire.sym} 2060 -3320 0 0 {name=l2501 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2060 -3240 0 0 {name=l2502 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1910 -3280 0 0 {name=l2503 sig_type=std_logic lab=WE1}
C {lab_wire.sym} 2240 -3280 0 0 {name=l2504 sig_type=std_logic lab=we1_buf}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1920 -3360 0 0 {name=X_inv73 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2080 -3360 0 0 {name=X_inv74 NF=16}
C {lab_wire.sym} 2060 -3440 0 0 {name=l2505 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2060 -3360 0 0 {name=l2506 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1910 -3400 0 0 {name=l2507 sig_type=std_logic lab=WE0}
C {lab_wire.sym} 2240 -3400 0 0 {name=l2508 sig_type=std_logic lab=we0_buf}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1100 -1050 0 0 {name=X_inv75 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1260 -1050 0 0 {name=X_inv76 NF=16}
C {lab_wire.sym} 1240 -1130 0 0 {name=l2509 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1240 -1050 0 0 {name=l2510 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1070 -1090 0 0 {name=l2511 sig_type=std_logic lab=Di0}
C {lab_wire.sym} 1420 -1090 0 0 {name=l2512 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 1480 -1090 0 0 {name=l2515 sig_type=std_logic lab=Di1}
C {lab_wire.sym} 1820 -1090 0 0 {name=l2516 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 1880 -1090 0 0 {name=l2519 sig_type=std_logic lab=Di2}
C {lab_wire.sym} 2220 -1090 0 0 {name=l2520 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 2280 -1090 0 0 {name=l2523 sig_type=std_logic lab=Di3}
C {lab_wire.sym} 2620 -1090 0 0 {name=l2524 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 1240 -1000 0 0 {name=l2525 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1240 -920 0 0 {name=l2526 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1070 -960 0 0 {name=l2527 sig_type=std_logic lab=Di4}
C {lab_wire.sym} 1420 -960 0 0 {name=l2528 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 1480 -960 0 0 {name=l2531 sig_type=std_logic lab=Di5}
C {lab_wire.sym} 1820 -960 0 0 {name=l2532 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 1880 -960 0 0 {name=l2535 sig_type=std_logic lab=Di6}
C {lab_wire.sym} 2220 -960 0 0 {name=l2536 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 2280 -960 0 0 {name=l2539 sig_type=std_logic lab=Di7}
C {lab_wire.sym} 2620 -960 0 0 {name=l2540 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 1240 -870 0 0 {name=l2541 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1240 -790 0 0 {name=l2542 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1070 -830 0 0 {name=l2543 sig_type=std_logic lab=Di8}
C {lab_wire.sym} 1420 -830 0 0 {name=l2544 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 1480 -830 0 0 {name=l2547 sig_type=std_logic lab=Di9}
C {lab_wire.sym} 1820 -830 0 0 {name=l2548 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 1880 -830 0 0 {name=l2551 sig_type=std_logic lab=Di10}
C {lab_wire.sym} 2220 -830 0 0 {name=l2552 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 2280 -830 0 0 {name=l2555 sig_type=std_logic lab=Di11}
C {lab_wire.sym} 2620 -830 0 0 {name=l2556 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 1240 -740 0 0 {name=l2557 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1240 -660 0 0 {name=l2558 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1070 -700 0 0 {name=l2559 sig_type=std_logic lab=Di12}
C {lab_wire.sym} 1420 -700 0 0 {name=l2560 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 1480 -700 0 0 {name=l2563 sig_type=std_logic lab=Di13}
C {lab_wire.sym} 1820 -700 0 0 {name=l2564 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 1880 -700 0 0 {name=l2567 sig_type=std_logic lab=Di14}
C {lab_wire.sym} 2220 -700 0 0 {name=l2568 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 2280 -700 0 0 {name=l2571 sig_type=std_logic lab=Di15}
C {lab_wire.sym} 2620 -700 0 0 {name=l2572 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 1240 -610 0 0 {name=l2573 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1240 -530 0 0 {name=l2574 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1070 -570 0 0 {name=l2575 sig_type=std_logic lab=Di16}
C {lab_wire.sym} 1420 -570 0 0 {name=l2576 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 1480 -570 0 0 {name=l2579 sig_type=std_logic lab=Di17}
C {lab_wire.sym} 1820 -570 0 0 {name=l2580 sig_type=std_logic lab=Di[17]}
C {lab_wire.sym} 1880 -570 0 0 {name=l2583 sig_type=std_logic lab=Di18}
C {lab_wire.sym} 2220 -570 0 0 {name=l2584 sig_type=std_logic lab=Di[18]}
C {lab_wire.sym} 2280 -570 0 0 {name=l2587 sig_type=std_logic lab=Di19}
C {lab_wire.sym} 2620 -570 0 0 {name=l2588 sig_type=std_logic lab=Di[19]}
C {lab_wire.sym} 1240 -480 0 0 {name=l2589 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1240 -400 0 0 {name=l2590 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1070 -440 0 0 {name=l2591 sig_type=std_logic lab=Di20}
C {lab_wire.sym} 1420 -440 0 0 {name=l2592 sig_type=std_logic lab=Di[20]}
C {lab_wire.sym} 1480 -440 0 0 {name=l2595 sig_type=std_logic lab=Di21}
C {lab_wire.sym} 1820 -440 0 0 {name=l2596 sig_type=std_logic lab=Di[21]}
C {lab_wire.sym} 1880 -440 0 0 {name=l2599 sig_type=std_logic lab=Di22}
C {lab_wire.sym} 2220 -440 0 0 {name=l2600 sig_type=std_logic lab=Di[22]}
C {lab_wire.sym} 2280 -440 0 0 {name=l2603 sig_type=std_logic lab=Di23}
C {lab_wire.sym} 2620 -440 0 0 {name=l2604 sig_type=std_logic lab=Di[23]}
C {lab_wire.sym} 1240 -350 0 0 {name=l2605 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1240 -270 0 0 {name=l2606 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1070 -310 0 0 {name=l2607 sig_type=std_logic lab=Di24}
C {lab_wire.sym} 1420 -310 0 0 {name=l2608 sig_type=std_logic lab=Di[24]}
C {lab_wire.sym} 1480 -310 0 0 {name=l2611 sig_type=std_logic lab=Di25}
C {lab_wire.sym} 1820 -310 0 0 {name=l2612 sig_type=std_logic lab=Di[25]}
C {lab_wire.sym} 1880 -310 0 0 {name=l2615 sig_type=std_logic lab=Di26}
C {lab_wire.sym} 2220 -310 0 0 {name=l2616 sig_type=std_logic lab=Di[26]}
C {lab_wire.sym} 2280 -310 0 0 {name=l2619 sig_type=std_logic lab=Di27}
C {lab_wire.sym} 2620 -310 0 0 {name=l2620 sig_type=std_logic lab=Di[27]}
C {lab_wire.sym} 1240 -220 0 0 {name=l2621 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1240 -140 0 0 {name=l2622 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1070 -180 0 0 {name=l2623 sig_type=std_logic lab=Di28}
C {lab_wire.sym} 1420 -180 0 0 {name=l2624 sig_type=std_logic lab=Di[28]}
C {lab_wire.sym} 1480 -180 0 0 {name=l2627 sig_type=std_logic lab=Di29}
C {lab_wire.sym} 1820 -180 0 0 {name=l2628 sig_type=std_logic lab=Di[29]}
C {lab_wire.sym} 1880 -180 0 0 {name=l2631 sig_type=std_logic lab=Di30}
C {lab_wire.sym} 2220 -180 0 0 {name=l2632 sig_type=std_logic lab=Di[30]}
C {lab_wire.sym} 2280 -180 0 0 {name=l2635 sig_type=std_logic lab=Di31}
C {lab_wire.sym} 2620 -180 0 0 {name=l2636 sig_type=std_logic lab=Di[31]}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1280 -3880 0 0 {name=X_inv139 NF=16}
C {lab_wire.sym} 1340 -3970 0 0 {name=l2639 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1340 -3870 2 0 {name=l2640 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 900 -3880 0 0 {name=X_inv143 NF=2}
C {lab_wire.sym} 960 -3970 0 0 {name=l2647 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 960 -3870 2 0 {name=l2648 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1460 -3880 0 0 {name=X_inv66 NF=32}
C {lab_wire.sym} 1520 -3970 0 0 {name=l2637 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1520 -3870 2 0 {name=l2638 sig_type=std_logic lab=VSS}
C {lab_pin.sym} 1080 -3230 0 0 {name=l2641 sig_type=std_logic lab=A3}
C {lab_pin.sym} 1080 -3210 0 0 {name=l2642 sig_type=std_logic lab=A4}
C {lab_pin.sym} 1080 -3190 0 0 {name=l2643 sig_type=std_logic lab=EN}
C {lab_pin.sym} 1080 -3090 0 0 {name=l2644 sig_type=std_logic lab=A2}
C {lab_pin.sym} 1080 -3070 0 0 {name=l2645 sig_type=std_logic lab=A1}
C {lab_pin.sym} 1080 -3050 0 0 {name=l2646 sig_type=std_logic lab=A0}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1100 -2360 0 0 {name=X_inv9 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1090 -2190 0 0 {name=X_inv17 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1090 -2020 0 0 {name=X_inv25 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1100 -1850 0 0 {name=X_inv33 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1100 -1680 0 0 {name=X_inv41 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1100 -1510 0 0 {name=X_inv49 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1100 -1340 0 0 {name=X_inv57 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1260 -2360 0 0 {name=X_inv10 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1250 -2190 0 0 {name=X_inv18 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1250 -2020 0 0 {name=X_inv26 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1260 -1850 0 0 {name=X_inv34 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1260 -1680 0 0 {name=X_inv42 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1260 -1510 0 0 {name=X_inv50 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1260 -1340 0 0 {name=X_inv58 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1460 -2360 0 0 {name=X_inv11 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1450 -2190 0 0 {name=X_inv12 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1450 -2020 0 0 {name=X_inv19 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1460 -1850 0 0 {name=X_inv20 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1460 -1680 0 0 {name=X_inv27 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1460 -1510 0 0 {name=X_inv28 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1460 -1340 0 0 {name=X_inv35 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1620 -2360 0 0 {name=X_inv36 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1610 -2190 0 0 {name=X_inv43 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1610 -2020 0 0 {name=X_inv44 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1620 -1850 0 0 {name=X_inv51 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1620 -1680 0 0 {name=X_inv52 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1620 -1510 0 0 {name=X_inv59 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1620 -1340 0 0 {name=X_inv60 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1840 -2530 0 0 {name=X_inv5 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1840 -2360 0 0 {name=X_inv13 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1830 -2190 0 0 {name=X_inv21 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1830 -2020 0 0 {name=X_inv29 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1840 -1850 0 0 {name=X_inv37 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1840 -1680 0 0 {name=X_inv45 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1840 -1510 0 0 {name=X_inv53 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1840 -1340 0 0 {name=X_inv61 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2000 -2530 0 0 {name=X_inv6 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2000 -2360 0 0 {name=X_inv14 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1990 -2190 0 0 {name=X_inv22 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1990 -2020 0 0 {name=X_inv30 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2000 -1850 0 0 {name=X_inv38 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2000 -1680 0 0 {name=X_inv46 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2000 -1510 0 0 {name=X_inv54 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2000 -1340 0 0 {name=X_inv62 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2200 -2530 0 0 {name=X_inv7 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2200 -2360 0 0 {name=X_inv15 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2190 -2190 0 0 {name=X_inv23 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2190 -2020 0 0 {name=X_inv31 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2200 -1850 0 0 {name=X_inv39 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2200 -1680 0 0 {name=X_inv47 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2200 -1510 0 0 {name=X_inv55 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2200 -1340 0 0 {name=X_inv63 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2360 -2530 0 0 {name=X_inv8 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2360 -2360 0 0 {name=X_inv16 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2350 -2190 0 0 {name=X_inv24 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2350 -2020 0 0 {name=X_inv32 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2360 -1850 0 0 {name=X_inv40 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2360 -1680 0 0 {name=X_inv48 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2360 -1510 0 0 {name=X_inv56 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2360 -1340 0 0 {name=X_inv64 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1100 -920 0 0 {name=X_inv83 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1100 -790 0 0 {name=X_inv91 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1100 -660 0 0 {name=X_inv99 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1100 -530 0 0 {name=X_inv107 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1100 -400 0 0 {name=X_inv115 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1100 -270 0 0 {name=X_inv123 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1100 -140 0 0 {name=X_inv131 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1260 -920 0 0 {name=X_inv84 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1260 -790 0 0 {name=X_inv92 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1260 -660 0 0 {name=X_inv100 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1260 -530 0 0 {name=X_inv108 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1260 -400 0 0 {name=X_inv116 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1260 -270 0 0 {name=X_inv124 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1260 -140 0 0 {name=X_inv132 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1500 -1050 0 0 {name=X_inv77 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1660 -1050 0 0 {name=X_inv78 NF=16}
C {lab_wire.sym} 1640 -1130 0 0 {name=l2513 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1640 -1050 0 0 {name=l2514 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1640 -1000 0 0 {name=l2529 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1640 -920 0 0 {name=l2530 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1640 -870 0 0 {name=l2545 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1640 -790 0 0 {name=l2546 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1640 -740 0 0 {name=l2561 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1640 -660 0 0 {name=l2562 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1640 -610 0 0 {name=l2577 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1640 -530 0 0 {name=l2578 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1640 -480 0 0 {name=l2593 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1640 -400 0 0 {name=l2594 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1640 -350 0 0 {name=l2609 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1640 -270 0 0 {name=l2610 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1640 -220 0 0 {name=l2625 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1640 -140 0 0 {name=l2626 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1500 -920 0 0 {name=X_inv85 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1500 -790 0 0 {name=X_inv86 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1500 -660 0 0 {name=X_inv93 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1500 -530 0 0 {name=X_inv94 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1500 -400 0 0 {name=X_inv101 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1500 -270 0 0 {name=X_inv102 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1500 -140 0 0 {name=X_inv109 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1660 -920 0 0 {name=X_inv110 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1660 -790 0 0 {name=X_inv117 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1660 -660 0 0 {name=X_inv118 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1660 -530 0 0 {name=X_inv125 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1660 -400 0 0 {name=X_inv126 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1660 -270 0 0 {name=X_inv133 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1660 -140 0 0 {name=X_inv134 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1900 -1050 0 0 {name=X_inv79 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2060 -1050 0 0 {name=X_inv80 NF=16}
C {lab_wire.sym} 2040 -1130 0 0 {name=l2517 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2040 -1050 0 0 {name=l2518 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2040 -1000 0 0 {name=l2521 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2040 -920 0 0 {name=l2522 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2040 -870 0 0 {name=l2533 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2040 -790 0 0 {name=l2534 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2040 -740 0 0 {name=l2537 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2040 -660 0 0 {name=l2538 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2040 -610 0 0 {name=l2549 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2040 -530 0 0 {name=l2550 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2040 -480 0 0 {name=l2553 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2040 -400 0 0 {name=l2554 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2040 -350 0 0 {name=l2565 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2040 -270 0 0 {name=l2566 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2040 -220 0 0 {name=l2569 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2040 -140 0 0 {name=l2570 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1900 -920 0 0 {name=X_inv81 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1900 -790 0 0 {name=X_inv82 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1900 -660 0 0 {name=X_inv87 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1900 -530 0 0 {name=X_inv88 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1900 -400 0 0 {name=X_inv89 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1900 -270 0 0 {name=X_inv90 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 1900 -140 0 0 {name=X_inv95 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2060 -920 0 0 {name=X_inv96 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2060 -790 0 0 {name=X_inv97 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2060 -660 0 0 {name=X_inv98 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2060 -530 0 0 {name=X_inv103 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2060 -400 0 0 {name=X_inv104 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2060 -270 0 0 {name=X_inv105 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2060 -140 0 0 {name=X_inv106 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2300 -1050 0 0 {name=X_inv111 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2460 -1050 0 0 {name=X_inv112 NF=16}
C {lab_wire.sym} 2440 -1130 0 0 {name=l2581 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2440 -1050 0 0 {name=l2582 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2440 -1000 0 0 {name=l2585 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2440 -920 0 0 {name=l2586 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2440 -870 0 0 {name=l2597 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2440 -790 0 0 {name=l2598 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2440 -740 0 0 {name=l2601 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2440 -660 0 0 {name=l2602 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2440 -610 0 0 {name=l2613 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2440 -530 0 0 {name=l2614 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2440 -480 0 0 {name=l2617 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2440 -400 0 0 {name=l2618 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2440 -350 0 0 {name=l2629 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2440 -270 0 0 {name=l2630 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2440 -220 0 0 {name=l2633 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2440 -140 0 0 {name=l2634 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2300 -920 0 0 {name=X_inv113 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2300 -790 0 0 {name=X_inv114 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2300 -660 0 0 {name=X_inv119 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2300 -530 0 0 {name=X_inv120 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2300 -400 0 0 {name=X_inv121 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2300 -270 0 0 {name=X_inv122 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2300 -140 0 0 {name=X_inv127 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2460 -920 0 0 {name=X_inv128 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2460 -790 0 0 {name=X_inv129 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2460 -660 0 0 {name=X_inv130 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2460 -530 0 0 {name=X_inv135 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2460 -400 0 0 {name=X_inv136 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2460 -270 0 0 {name=X_inv137 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2460 -140 0 0 {name=X_inv138 NF=16}
C {lab_wire.sym} 3680 -3690 2 0 {name=l104 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 3680 -3670 2 0 {name=l105 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 3680 -3650 2 0 {name=l106 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 3680 -3630 2 0 {name=l107 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 3680 -3610 2 0 {name=l108 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 3680 -3590 2 0 {name=l109 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 3680 -3570 2 0 {name=l110 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 3680 -3550 2 0 {name=l111 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 3680 -3530 2 0 {name=l112 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 3680 -3510 2 0 {name=l113 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 3680 -3490 2 0 {name=l114 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 3680 -3470 2 0 {name=l115 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 3680 -3450 2 0 {name=l116 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 3680 -3430 2 0 {name=l117 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 3680 -3410 2 0 {name=l118 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 3680 -3390 2 0 {name=l119 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 3680 -3370 2 0 {name=l120 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 3680 -3350 2 0 {name=l121 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 3680 -3330 2 0 {name=l122 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 3680 -3310 2 0 {name=l123 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 3680 -3290 2 0 {name=l124 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 3680 -3270 2 0 {name=l125 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 3680 -3250 2 0 {name=l126 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 3680 -3230 2 0 {name=l127 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 3680 -3210 2 0 {name=l128 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 3680 -3190 2 0 {name=l129 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 3680 -3170 2 0 {name=l130 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 3680 -3150 2 0 {name=l131 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 3680 -3130 2 0 {name=l132 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 3680 -3110 2 0 {name=l133 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 3680 -3090 2 0 {name=l134 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 3680 -3070 2 0 {name=l135 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 4220 -3690 2 0 {name=l175 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 4220 -3670 2 0 {name=l176 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 4220 -3650 2 0 {name=l177 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 4220 -3630 2 0 {name=l178 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 4220 -3610 2 0 {name=l179 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 4220 -3590 2 0 {name=l180 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 4220 -3570 2 0 {name=l181 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 4220 -3550 2 0 {name=l182 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 4220 -3530 2 0 {name=l183 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 4220 -3510 2 0 {name=l184 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 4220 -3490 2 0 {name=l185 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 4220 -3470 2 0 {name=l186 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 4220 -3450 2 0 {name=l187 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 4220 -3430 2 0 {name=l188 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 4220 -3410 2 0 {name=l189 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 4220 -3390 2 0 {name=l190 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 4220 -3370 2 0 {name=l191 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 4220 -3350 2 0 {name=l192 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 4220 -3330 2 0 {name=l193 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 4220 -3310 2 0 {name=l194 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 4220 -3290 2 0 {name=l195 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 4220 -3270 2 0 {name=l196 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 4220 -3250 2 0 {name=l197 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 4220 -3230 2 0 {name=l198 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 4220 -3210 2 0 {name=l199 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 4220 -3190 2 0 {name=l200 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 4220 -3170 2 0 {name=l201 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 4220 -3150 2 0 {name=l202 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 4220 -3130 2 0 {name=l203 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 4220 -3110 2 0 {name=l204 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 4220 -3090 2 0 {name=l205 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 4220 -3070 2 0 {name=l206 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 4740 -3690 2 0 {name=l246 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 4740 -3670 2 0 {name=l247 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 4740 -3650 2 0 {name=l248 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 4740 -3630 2 0 {name=l249 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 4740 -3610 2 0 {name=l250 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 4740 -3590 2 0 {name=l251 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 4740 -3570 2 0 {name=l252 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 4740 -3550 2 0 {name=l253 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 4740 -3530 2 0 {name=l254 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 4740 -3510 2 0 {name=l255 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 4740 -3490 2 0 {name=l256 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 4740 -3470 2 0 {name=l257 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 4740 -3450 2 0 {name=l258 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 4740 -3430 2 0 {name=l259 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 4740 -3410 2 0 {name=l260 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 4740 -3390 2 0 {name=l261 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 4740 -3370 2 0 {name=l262 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 4740 -3350 2 0 {name=l263 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 4740 -3330 2 0 {name=l264 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 4740 -3310 2 0 {name=l265 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 4740 -3290 2 0 {name=l266 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 4740 -3270 2 0 {name=l267 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 4740 -3250 2 0 {name=l268 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 4740 -3230 2 0 {name=l269 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 4740 -3210 2 0 {name=l270 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 4740 -3190 2 0 {name=l271 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 4740 -3170 2 0 {name=l272 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 4740 -3150 2 0 {name=l273 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 4740 -3130 2 0 {name=l274 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 4740 -3110 2 0 {name=l275 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 4740 -3090 2 0 {name=l276 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 4740 -3070 2 0 {name=l277 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 5260 -3690 2 0 {name=l317 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 5260 -3670 2 0 {name=l318 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 5260 -3650 2 0 {name=l319 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 5260 -3630 2 0 {name=l320 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 5260 -3610 2 0 {name=l321 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 5260 -3590 2 0 {name=l322 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 5260 -3570 2 0 {name=l323 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 5260 -3550 2 0 {name=l324 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 5260 -3530 2 0 {name=l325 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 5260 -3510 2 0 {name=l326 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 5260 -3490 2 0 {name=l327 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 5260 -3470 2 0 {name=l328 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 5260 -3450 2 0 {name=l329 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 5260 -3430 2 0 {name=l330 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 5260 -3410 2 0 {name=l331 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 5260 -3390 2 0 {name=l332 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 5260 -3370 2 0 {name=l333 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 5260 -3350 2 0 {name=l334 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 5260 -3330 2 0 {name=l335 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 5260 -3310 2 0 {name=l336 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 5260 -3290 2 0 {name=l337 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 5260 -3270 2 0 {name=l338 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 5260 -3250 2 0 {name=l339 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 5260 -3230 2 0 {name=l340 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 5260 -3210 2 0 {name=l341 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 5260 -3190 2 0 {name=l342 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 5260 -3170 2 0 {name=l343 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 5260 -3150 2 0 {name=l344 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 5260 -3130 2 0 {name=l345 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 5260 -3110 2 0 {name=l346 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 5260 -3090 2 0 {name=l347 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 5260 -3070 2 0 {name=l348 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 5780 -3690 2 0 {name=l388 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 5780 -3670 2 0 {name=l389 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 5780 -3650 2 0 {name=l390 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 5780 -3630 2 0 {name=l391 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 5780 -3610 2 0 {name=l392 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 5780 -3590 2 0 {name=l393 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 5780 -3570 2 0 {name=l394 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 5780 -3550 2 0 {name=l395 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 5780 -3530 2 0 {name=l396 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 5780 -3510 2 0 {name=l397 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 5780 -3490 2 0 {name=l398 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 5780 -3470 2 0 {name=l399 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 5780 -3450 2 0 {name=l400 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 5780 -3430 2 0 {name=l401 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 5780 -3410 2 0 {name=l402 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 5780 -3390 2 0 {name=l403 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 5780 -3370 2 0 {name=l404 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 5780 -3350 2 0 {name=l405 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 5780 -3330 2 0 {name=l406 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 5780 -3310 2 0 {name=l407 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 5780 -3290 2 0 {name=l408 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 5780 -3270 2 0 {name=l409 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 5780 -3250 2 0 {name=l410 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 5780 -3230 2 0 {name=l411 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 5780 -3210 2 0 {name=l412 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 5780 -3190 2 0 {name=l413 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 5780 -3170 2 0 {name=l414 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 5780 -3150 2 0 {name=l415 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 5780 -3130 2 0 {name=l416 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 5780 -3110 2 0 {name=l417 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 5780 -3090 2 0 {name=l418 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 5780 -3070 2 0 {name=l419 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 6320 -3690 2 0 {name=l459 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 6320 -3670 2 0 {name=l460 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 6320 -3650 2 0 {name=l461 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 6320 -3630 2 0 {name=l462 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 6320 -3610 2 0 {name=l463 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 6320 -3590 2 0 {name=l464 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 6320 -3570 2 0 {name=l465 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 6320 -3550 2 0 {name=l466 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 6320 -3530 2 0 {name=l467 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 6320 -3510 2 0 {name=l468 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 6320 -3490 2 0 {name=l469 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 6320 -3470 2 0 {name=l470 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 6320 -3450 2 0 {name=l471 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 6320 -3430 2 0 {name=l472 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 6320 -3410 2 0 {name=l473 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 6320 -3390 2 0 {name=l474 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 6320 -3370 2 0 {name=l475 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 6320 -3350 2 0 {name=l476 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 6320 -3330 2 0 {name=l477 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 6320 -3310 2 0 {name=l478 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 6320 -3290 2 0 {name=l479 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 6320 -3270 2 0 {name=l480 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 6320 -3250 2 0 {name=l481 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 6320 -3230 2 0 {name=l482 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 6320 -3210 2 0 {name=l483 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 6320 -3190 2 0 {name=l484 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 6320 -3170 2 0 {name=l485 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 6320 -3150 2 0 {name=l486 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 6320 -3130 2 0 {name=l487 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 6320 -3110 2 0 {name=l488 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 6320 -3090 2 0 {name=l489 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 6320 -3070 2 0 {name=l490 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 6840 -3690 2 0 {name=l530 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 6840 -3670 2 0 {name=l531 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 6840 -3650 2 0 {name=l532 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 6840 -3630 2 0 {name=l533 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 6840 -3610 2 0 {name=l534 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 6840 -3590 2 0 {name=l535 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 6840 -3570 2 0 {name=l536 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 6840 -3550 2 0 {name=l537 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 6840 -3530 2 0 {name=l538 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 6840 -3510 2 0 {name=l539 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 6840 -3490 2 0 {name=l540 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 6840 -3470 2 0 {name=l541 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 6840 -3450 2 0 {name=l542 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 6840 -3430 2 0 {name=l543 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 6840 -3410 2 0 {name=l544 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 6840 -3390 2 0 {name=l545 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 6840 -3370 2 0 {name=l546 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 6840 -3350 2 0 {name=l547 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 6840 -3330 2 0 {name=l548 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 6840 -3310 2 0 {name=l549 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 6840 -3290 2 0 {name=l550 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 6840 -3270 2 0 {name=l551 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 6840 -3250 2 0 {name=l552 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 6840 -3230 2 0 {name=l553 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 6840 -3210 2 0 {name=l554 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 6840 -3190 2 0 {name=l555 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 6840 -3170 2 0 {name=l556 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 6840 -3150 2 0 {name=l557 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 6840 -3130 2 0 {name=l558 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 6840 -3110 2 0 {name=l559 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 6840 -3090 2 0 {name=l560 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 6840 -3070 2 0 {name=l561 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 3160 -2790 2 0 {name=l601 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 3160 -2770 2 0 {name=l602 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 3160 -2750 2 0 {name=l603 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 3160 -2730 2 0 {name=l604 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 3160 -2710 2 0 {name=l605 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 3160 -2690 2 0 {name=l606 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 3160 -2670 2 0 {name=l607 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 3160 -2650 2 0 {name=l608 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 3160 -2630 2 0 {name=l609 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 3160 -2610 2 0 {name=l610 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 3160 -2590 2 0 {name=l611 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 3160 -2570 2 0 {name=l612 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 3160 -2550 2 0 {name=l613 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 3160 -2530 2 0 {name=l614 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 3160 -2510 2 0 {name=l615 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 3160 -2490 2 0 {name=l616 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 3160 -2470 2 0 {name=l617 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 3160 -2450 2 0 {name=l618 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 3160 -2430 2 0 {name=l619 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 3160 -2410 2 0 {name=l620 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 3160 -2390 2 0 {name=l621 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 3160 -2370 2 0 {name=l622 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 3160 -2350 2 0 {name=l623 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 3160 -2330 2 0 {name=l624 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 3160 -2310 2 0 {name=l625 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 3160 -2290 2 0 {name=l626 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 3160 -2270 2 0 {name=l627 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 3160 -2250 2 0 {name=l628 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 3160 -2230 2 0 {name=l629 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 3160 -2210 2 0 {name=l630 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 3160 -2190 2 0 {name=l631 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 3160 -2170 2 0 {name=l632 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 3170 -1840 2 0 {name=l1169 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 3170 -1820 2 0 {name=l1170 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 3170 -1800 2 0 {name=l1171 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 3170 -1780 2 0 {name=l1172 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 3170 -1760 2 0 {name=l1173 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 3170 -1740 2 0 {name=l1174 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 3170 -1720 2 0 {name=l1175 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 3170 -1700 2 0 {name=l1176 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 3170 -1680 2 0 {name=l1177 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 3170 -1660 2 0 {name=l1178 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 3170 -1640 2 0 {name=l1179 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 3170 -1620 2 0 {name=l1180 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 3170 -1600 2 0 {name=l1181 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 3170 -1580 2 0 {name=l1182 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 3170 -1560 2 0 {name=l1183 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 3170 -1540 2 0 {name=l1184 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 3170 -1520 2 0 {name=l1185 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 3170 -1500 2 0 {name=l1186 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 3170 -1480 2 0 {name=l1187 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 3170 -1460 2 0 {name=l1188 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 3170 -1440 2 0 {name=l1189 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 3170 -1420 2 0 {name=l1190 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 3170 -1400 2 0 {name=l1191 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 3170 -1380 2 0 {name=l1192 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 3170 -1360 2 0 {name=l1193 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 3170 -1340 2 0 {name=l1194 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 3170 -1320 2 0 {name=l1195 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 3170 -1300 2 0 {name=l1196 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 3170 -1280 2 0 {name=l1197 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 3170 -1260 2 0 {name=l1198 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 3170 -1240 2 0 {name=l1199 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 3170 -1220 2 0 {name=l1200 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 3170 -940 2 0 {name=l1737 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 3170 -920 2 0 {name=l1738 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 3170 -900 2 0 {name=l1739 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 3170 -880 2 0 {name=l1740 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 3170 -860 2 0 {name=l1741 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 3170 -840 2 0 {name=l1742 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 3170 -820 2 0 {name=l1743 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 3170 -800 2 0 {name=l1744 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 3170 -780 2 0 {name=l1745 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 3170 -760 2 0 {name=l1746 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 3170 -740 2 0 {name=l1747 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 3170 -720 2 0 {name=l1748 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 3170 -700 2 0 {name=l1749 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 3170 -680 2 0 {name=l1750 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 3170 -660 2 0 {name=l1751 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 3170 -640 2 0 {name=l1752 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 3170 -620 2 0 {name=l1753 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 3170 -600 2 0 {name=l1754 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 3170 -580 2 0 {name=l1755 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 3170 -560 2 0 {name=l1756 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 3170 -540 2 0 {name=l1757 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 3170 -520 2 0 {name=l1758 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 3170 -500 2 0 {name=l1759 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 3170 -480 2 0 {name=l1760 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 3170 -460 2 0 {name=l1761 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 3170 -440 2 0 {name=l1762 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 3170 -420 2 0 {name=l1763 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 3170 -400 2 0 {name=l1764 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 3170 -380 2 0 {name=l1765 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 3170 -360 2 0 {name=l1766 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 3170 -340 2 0 {name=l1767 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 3170 -320 2 0 {name=l1768 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 3680 -2790 2 0 {name=l672 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 3680 -2770 2 0 {name=l673 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 3680 -2750 2 0 {name=l674 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 3680 -2730 2 0 {name=l675 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 3680 -2710 2 0 {name=l676 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 3680 -2690 2 0 {name=l677 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 3680 -2670 2 0 {name=l678 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 3680 -2650 2 0 {name=l679 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 3680 -2630 2 0 {name=l680 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 3680 -2610 2 0 {name=l681 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 3680 -2590 2 0 {name=l682 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 3680 -2570 2 0 {name=l683 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 3680 -2550 2 0 {name=l684 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 3680 -2530 2 0 {name=l685 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 3680 -2510 2 0 {name=l686 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 3680 -2490 2 0 {name=l687 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 3680 -2470 2 0 {name=l688 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 3680 -2450 2 0 {name=l689 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 3680 -2430 2 0 {name=l690 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 3680 -2410 2 0 {name=l691 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 3680 -2390 2 0 {name=l692 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 3680 -2370 2 0 {name=l693 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 3680 -2350 2 0 {name=l694 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 3680 -2330 2 0 {name=l695 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 3680 -2310 2 0 {name=l696 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 3680 -2290 2 0 {name=l697 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 3680 -2270 2 0 {name=l698 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 3680 -2250 2 0 {name=l699 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 3680 -2230 2 0 {name=l700 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 3680 -2210 2 0 {name=l701 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 3680 -2190 2 0 {name=l702 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 3680 -2170 2 0 {name=l703 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 3690 -1840 2 0 {name=l1240 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 3690 -1820 2 0 {name=l1241 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 3690 -1800 2 0 {name=l1242 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 3690 -1780 2 0 {name=l1243 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 3690 -1760 2 0 {name=l1244 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 3690 -1740 2 0 {name=l1245 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 3690 -1720 2 0 {name=l1246 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 3690 -1700 2 0 {name=l1247 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 3690 -1680 2 0 {name=l1248 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 3690 -1660 2 0 {name=l1249 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 3690 -1640 2 0 {name=l1250 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 3690 -1620 2 0 {name=l1251 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 3690 -1600 2 0 {name=l1252 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 3690 -1580 2 0 {name=l1253 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 3690 -1560 2 0 {name=l1254 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 3690 -1540 2 0 {name=l1255 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 3690 -1520 2 0 {name=l1256 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 3690 -1500 2 0 {name=l1257 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 3690 -1480 2 0 {name=l1258 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 3690 -1460 2 0 {name=l1259 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 3690 -1440 2 0 {name=l1260 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 3690 -1420 2 0 {name=l1261 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 3690 -1400 2 0 {name=l1262 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 3690 -1380 2 0 {name=l1263 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 3690 -1360 2 0 {name=l1264 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 3690 -1340 2 0 {name=l1265 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 3690 -1320 2 0 {name=l1266 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 3690 -1300 2 0 {name=l1267 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 3690 -1280 2 0 {name=l1268 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 3690 -1260 2 0 {name=l1269 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 3690 -1240 2 0 {name=l1270 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 3690 -1220 2 0 {name=l1271 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 3690 -940 2 0 {name=l1808 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 3690 -920 2 0 {name=l1809 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 3690 -900 2 0 {name=l1810 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 3690 -880 2 0 {name=l1811 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 3690 -860 2 0 {name=l1812 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 3690 -840 2 0 {name=l1813 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 3690 -820 2 0 {name=l1814 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 3690 -800 2 0 {name=l1815 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 3690 -780 2 0 {name=l1816 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 3690 -760 2 0 {name=l1817 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 3690 -740 2 0 {name=l1818 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 3690 -720 2 0 {name=l1819 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 3690 -700 2 0 {name=l1820 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 3690 -680 2 0 {name=l1821 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 3690 -660 2 0 {name=l1822 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 3690 -640 2 0 {name=l1823 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 3690 -620 2 0 {name=l1824 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 3690 -600 2 0 {name=l1825 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 3690 -580 2 0 {name=l1826 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 3690 -560 2 0 {name=l1827 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 3690 -540 2 0 {name=l1828 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 3690 -520 2 0 {name=l1829 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 3690 -500 2 0 {name=l1830 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 3690 -480 2 0 {name=l1831 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 3690 -460 2 0 {name=l1832 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 3690 -440 2 0 {name=l1833 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 3690 -420 2 0 {name=l1834 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 3690 -400 2 0 {name=l1835 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 3690 -380 2 0 {name=l1836 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 3690 -360 2 0 {name=l1837 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 3690 -340 2 0 {name=l1838 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 3690 -320 2 0 {name=l1839 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 4220 -2790 2 0 {name=l743 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 4220 -2770 2 0 {name=l744 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 4220 -2750 2 0 {name=l745 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 4220 -2730 2 0 {name=l746 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 4220 -2710 2 0 {name=l747 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 4220 -2690 2 0 {name=l748 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 4220 -2670 2 0 {name=l749 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 4220 -2650 2 0 {name=l750 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 4220 -2630 2 0 {name=l751 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 4220 -2610 2 0 {name=l752 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 4220 -2590 2 0 {name=l753 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 4220 -2570 2 0 {name=l754 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 4220 -2550 2 0 {name=l755 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 4220 -2530 2 0 {name=l756 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 4220 -2510 2 0 {name=l757 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 4220 -2490 2 0 {name=l758 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 4220 -2470 2 0 {name=l759 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 4220 -2450 2 0 {name=l760 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 4220 -2430 2 0 {name=l761 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 4220 -2410 2 0 {name=l762 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 4220 -2390 2 0 {name=l763 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 4220 -2370 2 0 {name=l764 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 4220 -2350 2 0 {name=l765 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 4220 -2330 2 0 {name=l766 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 4220 -2310 2 0 {name=l767 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 4220 -2290 2 0 {name=l768 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 4220 -2270 2 0 {name=l769 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 4220 -2250 2 0 {name=l770 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 4220 -2230 2 0 {name=l771 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 4220 -2210 2 0 {name=l772 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 4220 -2190 2 0 {name=l773 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 4220 -2170 2 0 {name=l774 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 4230 -1840 2 0 {name=l1311 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 4230 -1820 2 0 {name=l1312 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 4230 -1800 2 0 {name=l1313 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 4230 -1780 2 0 {name=l1314 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 4230 -1760 2 0 {name=l1315 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 4230 -1740 2 0 {name=l1316 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 4230 -1720 2 0 {name=l1317 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 4230 -1700 2 0 {name=l1318 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 4230 -1680 2 0 {name=l1319 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 4230 -1660 2 0 {name=l1320 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 4230 -1640 2 0 {name=l1321 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 4230 -1620 2 0 {name=l1322 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 4230 -1600 2 0 {name=l1323 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 4230 -1580 2 0 {name=l1324 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 4230 -1560 2 0 {name=l1325 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 4230 -1540 2 0 {name=l1326 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 4230 -1520 2 0 {name=l1327 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 4230 -1500 2 0 {name=l1328 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 4230 -1480 2 0 {name=l1329 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 4230 -1460 2 0 {name=l1330 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 4230 -1440 2 0 {name=l1331 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 4230 -1420 2 0 {name=l1332 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 4230 -1400 2 0 {name=l1333 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 4230 -1380 2 0 {name=l1334 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 4230 -1360 2 0 {name=l1335 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 4230 -1340 2 0 {name=l1336 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 4230 -1320 2 0 {name=l1337 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 4230 -1300 2 0 {name=l1338 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 4230 -1280 2 0 {name=l1339 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 4230 -1260 2 0 {name=l1340 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 4230 -1240 2 0 {name=l1341 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 4230 -1220 2 0 {name=l1342 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 4230 -940 2 0 {name=l1879 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 4230 -920 2 0 {name=l1880 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 4230 -900 2 0 {name=l1881 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 4230 -880 2 0 {name=l1882 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 4230 -860 2 0 {name=l1883 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 4230 -840 2 0 {name=l1884 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 4230 -820 2 0 {name=l1885 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 4230 -800 2 0 {name=l1886 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 4230 -780 2 0 {name=l1887 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 4230 -760 2 0 {name=l1888 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 4230 -740 2 0 {name=l1889 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 4230 -720 2 0 {name=l1890 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 4230 -700 2 0 {name=l1891 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 4230 -680 2 0 {name=l1892 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 4230 -660 2 0 {name=l1893 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 4230 -640 2 0 {name=l1894 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 4230 -620 2 0 {name=l1895 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 4230 -600 2 0 {name=l1896 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 4230 -580 2 0 {name=l1897 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 4230 -560 2 0 {name=l1898 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 4230 -540 2 0 {name=l1899 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 4230 -520 2 0 {name=l1900 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 4230 -500 2 0 {name=l1901 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 4230 -480 2 0 {name=l1902 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 4230 -460 2 0 {name=l1903 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 4230 -440 2 0 {name=l1904 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 4230 -420 2 0 {name=l1905 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 4230 -400 2 0 {name=l1906 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 4230 -380 2 0 {name=l1907 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 4230 -360 2 0 {name=l1908 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 4230 -340 2 0 {name=l1909 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 4230 -320 2 0 {name=l1910 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 4740 -2790 2 0 {name=l814 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 4740 -2770 2 0 {name=l815 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 4740 -2750 2 0 {name=l816 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 4740 -2730 2 0 {name=l817 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 4740 -2710 2 0 {name=l818 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 4740 -2690 2 0 {name=l819 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 4740 -2670 2 0 {name=l820 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 4740 -2650 2 0 {name=l821 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 4740 -2630 2 0 {name=l822 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 4740 -2610 2 0 {name=l823 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 4740 -2590 2 0 {name=l824 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 4740 -2570 2 0 {name=l825 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 4740 -2550 2 0 {name=l826 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 4740 -2530 2 0 {name=l827 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 4740 -2510 2 0 {name=l828 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 4740 -2490 2 0 {name=l829 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 4740 -2470 2 0 {name=l830 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 4740 -2450 2 0 {name=l831 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 4740 -2430 2 0 {name=l832 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 4740 -2410 2 0 {name=l833 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 4740 -2390 2 0 {name=l834 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 4740 -2370 2 0 {name=l835 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 4740 -2350 2 0 {name=l836 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 4740 -2330 2 0 {name=l837 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 4740 -2310 2 0 {name=l838 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 4740 -2290 2 0 {name=l839 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 4740 -2270 2 0 {name=l840 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 4740 -2250 2 0 {name=l841 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 4740 -2230 2 0 {name=l842 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 4740 -2210 2 0 {name=l843 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 4740 -2190 2 0 {name=l844 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 4740 -2170 2 0 {name=l845 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 4750 -1840 2 0 {name=l1382 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 4750 -1820 2 0 {name=l1383 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 4750 -1800 2 0 {name=l1384 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 4750 -1780 2 0 {name=l1385 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 4750 -1760 2 0 {name=l1386 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 4750 -1740 2 0 {name=l1387 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 4750 -1720 2 0 {name=l1388 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 4750 -1700 2 0 {name=l1389 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 4750 -1680 2 0 {name=l1390 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 4750 -1660 2 0 {name=l1391 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 4750 -1640 2 0 {name=l1392 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 4750 -1620 2 0 {name=l1393 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 4750 -1600 2 0 {name=l1394 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 4750 -1580 2 0 {name=l1395 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 4750 -1560 2 0 {name=l1396 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 4750 -1540 2 0 {name=l1397 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 4750 -1520 2 0 {name=l1398 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 4750 -1500 2 0 {name=l1399 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 4750 -1480 2 0 {name=l1400 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 4750 -1460 2 0 {name=l1401 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 4750 -1440 2 0 {name=l1402 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 4750 -1420 2 0 {name=l1403 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 4750 -1400 2 0 {name=l1404 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 4750 -1380 2 0 {name=l1405 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 4750 -1360 2 0 {name=l1406 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 4750 -1340 2 0 {name=l1407 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 4750 -1320 2 0 {name=l1408 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 4750 -1300 2 0 {name=l1409 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 4750 -1280 2 0 {name=l1410 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 4750 -1260 2 0 {name=l1411 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 4750 -1240 2 0 {name=l1412 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 4750 -1220 2 0 {name=l1413 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 4750 -940 2 0 {name=l1950 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 4750 -920 2 0 {name=l1951 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 4750 -900 2 0 {name=l1952 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 4750 -880 2 0 {name=l1953 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 4750 -860 2 0 {name=l1954 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 4750 -840 2 0 {name=l1955 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 4750 -820 2 0 {name=l1956 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 4750 -800 2 0 {name=l1957 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 4750 -780 2 0 {name=l1958 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 4750 -760 2 0 {name=l1959 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 4750 -740 2 0 {name=l1960 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 4750 -720 2 0 {name=l1961 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 4750 -700 2 0 {name=l1962 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 4750 -680 2 0 {name=l1963 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 4750 -660 2 0 {name=l1964 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 4750 -640 2 0 {name=l1965 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 4750 -620 2 0 {name=l1966 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 4750 -600 2 0 {name=l1967 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 4750 -580 2 0 {name=l1968 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 4750 -560 2 0 {name=l1969 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 4750 -540 2 0 {name=l1970 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 4750 -520 2 0 {name=l1971 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 4750 -500 2 0 {name=l1972 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 4750 -480 2 0 {name=l1973 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 4750 -460 2 0 {name=l1974 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 4750 -440 2 0 {name=l1975 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 4750 -420 2 0 {name=l1976 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 4750 -400 2 0 {name=l1977 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 4750 -380 2 0 {name=l1978 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 4750 -360 2 0 {name=l1979 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 4750 -340 2 0 {name=l1980 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 4750 -320 2 0 {name=l1981 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 5260 -2790 2 0 {name=l885 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 5260 -2770 2 0 {name=l886 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 5260 -2750 2 0 {name=l887 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 5260 -2730 2 0 {name=l888 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 5260 -2710 2 0 {name=l889 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 5260 -2690 2 0 {name=l890 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 5260 -2670 2 0 {name=l891 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 5260 -2650 2 0 {name=l892 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 5260 -2630 2 0 {name=l893 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 5260 -2610 2 0 {name=l894 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 5260 -2590 2 0 {name=l895 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 5260 -2570 2 0 {name=l896 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 5260 -2550 2 0 {name=l897 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 5260 -2530 2 0 {name=l898 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 5260 -2510 2 0 {name=l899 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 5260 -2490 2 0 {name=l900 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 5260 -2470 2 0 {name=l901 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 5260 -2450 2 0 {name=l902 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 5260 -2430 2 0 {name=l903 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 5260 -2410 2 0 {name=l904 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 5260 -2390 2 0 {name=l905 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 5260 -2370 2 0 {name=l906 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 5260 -2350 2 0 {name=l907 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 5260 -2330 2 0 {name=l908 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 5260 -2310 2 0 {name=l909 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 5260 -2290 2 0 {name=l910 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 5260 -2270 2 0 {name=l911 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 5260 -2250 2 0 {name=l912 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 5260 -2230 2 0 {name=l913 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 5260 -2210 2 0 {name=l914 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 5260 -2190 2 0 {name=l915 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 5260 -2170 2 0 {name=l916 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 5270 -1840 2 0 {name=l1453 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 5270 -1820 2 0 {name=l1454 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 5270 -1800 2 0 {name=l1455 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 5270 -1780 2 0 {name=l1456 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 5270 -1760 2 0 {name=l1457 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 5270 -1740 2 0 {name=l1458 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 5270 -1720 2 0 {name=l1459 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 5270 -1700 2 0 {name=l1460 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 5270 -1680 2 0 {name=l1461 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 5270 -1660 2 0 {name=l1462 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 5270 -1640 2 0 {name=l1463 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 5270 -1620 2 0 {name=l1464 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 5270 -1600 2 0 {name=l1465 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 5270 -1580 2 0 {name=l1466 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 5270 -1560 2 0 {name=l1467 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 5270 -1540 2 0 {name=l1468 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 5270 -1520 2 0 {name=l1469 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 5270 -1500 2 0 {name=l1470 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 5270 -1480 2 0 {name=l1471 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 5270 -1460 2 0 {name=l1472 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 5270 -1440 2 0 {name=l1473 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 5270 -1420 2 0 {name=l1474 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 5270 -1400 2 0 {name=l1475 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 5270 -1380 2 0 {name=l1476 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 5270 -1360 2 0 {name=l1477 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 5270 -1340 2 0 {name=l1478 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 5270 -1320 2 0 {name=l1479 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 5270 -1300 2 0 {name=l1480 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 5270 -1280 2 0 {name=l1481 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 5270 -1260 2 0 {name=l1482 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 5270 -1240 2 0 {name=l1483 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 5270 -1220 2 0 {name=l1484 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 5270 -940 2 0 {name=l2021 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 5270 -920 2 0 {name=l2022 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 5270 -900 2 0 {name=l2023 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 5270 -880 2 0 {name=l2024 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 5270 -860 2 0 {name=l2025 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 5270 -840 2 0 {name=l2026 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 5270 -820 2 0 {name=l2027 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 5270 -800 2 0 {name=l2028 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 5270 -780 2 0 {name=l2029 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 5270 -760 2 0 {name=l2030 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 5270 -740 2 0 {name=l2031 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 5270 -720 2 0 {name=l2032 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 5270 -700 2 0 {name=l2033 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 5270 -680 2 0 {name=l2034 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 5270 -660 2 0 {name=l2035 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 5270 -640 2 0 {name=l2036 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 5270 -620 2 0 {name=l2037 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 5270 -600 2 0 {name=l2038 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 5270 -580 2 0 {name=l2039 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 5270 -560 2 0 {name=l2040 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 5270 -540 2 0 {name=l2041 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 5270 -520 2 0 {name=l2042 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 5270 -500 2 0 {name=l2043 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 5270 -480 2 0 {name=l2044 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 5270 -460 2 0 {name=l2045 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 5270 -440 2 0 {name=l2046 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 5270 -420 2 0 {name=l2047 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 5270 -400 2 0 {name=l2048 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 5270 -380 2 0 {name=l2049 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 5270 -360 2 0 {name=l2050 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 5270 -340 2 0 {name=l2051 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 5270 -320 2 0 {name=l2052 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 5780 -2790 2 0 {name=l956 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 5780 -2770 2 0 {name=l957 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 5780 -2750 2 0 {name=l958 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 5780 -2730 2 0 {name=l959 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 5780 -2710 2 0 {name=l960 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 5780 -2690 2 0 {name=l961 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 5780 -2670 2 0 {name=l962 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 5780 -2650 2 0 {name=l963 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 5780 -2630 2 0 {name=l964 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 5780 -2610 2 0 {name=l965 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 5780 -2590 2 0 {name=l966 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 5780 -2570 2 0 {name=l967 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 5780 -2550 2 0 {name=l968 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 5780 -2530 2 0 {name=l969 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 5780 -2510 2 0 {name=l970 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 5780 -2490 2 0 {name=l971 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 5780 -2470 2 0 {name=l972 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 5780 -2450 2 0 {name=l973 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 5780 -2430 2 0 {name=l974 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 5780 -2410 2 0 {name=l975 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 5780 -2390 2 0 {name=l976 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 5780 -2370 2 0 {name=l977 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 5780 -2350 2 0 {name=l978 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 5780 -2330 2 0 {name=l979 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 5780 -2310 2 0 {name=l980 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 5780 -2290 2 0 {name=l981 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 5780 -2270 2 0 {name=l982 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 5780 -2250 2 0 {name=l983 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 5780 -2230 2 0 {name=l984 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 5780 -2210 2 0 {name=l985 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 5780 -2190 2 0 {name=l986 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 5780 -2170 2 0 {name=l987 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 5790 -1840 2 0 {name=l1524 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 5790 -1820 2 0 {name=l1525 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 5790 -1800 2 0 {name=l1526 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 5790 -1780 2 0 {name=l1527 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 5790 -1760 2 0 {name=l1528 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 5790 -1740 2 0 {name=l1529 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 5790 -1720 2 0 {name=l1530 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 5790 -1700 2 0 {name=l1531 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 5790 -1680 2 0 {name=l1532 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 5790 -1660 2 0 {name=l1533 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 5790 -1640 2 0 {name=l1534 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 5790 -1620 2 0 {name=l1535 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 5790 -1600 2 0 {name=l1536 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 5790 -1580 2 0 {name=l1537 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 5790 -1560 2 0 {name=l1538 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 5790 -1540 2 0 {name=l1539 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 5790 -1520 2 0 {name=l1540 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 5790 -1500 2 0 {name=l1541 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 5790 -1480 2 0 {name=l1542 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 5790 -1460 2 0 {name=l1543 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 5790 -1440 2 0 {name=l1544 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 5790 -1420 2 0 {name=l1545 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 5790 -1400 2 0 {name=l1546 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 5790 -1380 2 0 {name=l1547 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 5790 -1360 2 0 {name=l1548 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 5790 -1340 2 0 {name=l1549 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 5790 -1320 2 0 {name=l1550 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 5790 -1300 2 0 {name=l1551 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 5790 -1280 2 0 {name=l1552 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 5790 -1260 2 0 {name=l1553 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 5790 -1240 2 0 {name=l1554 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 5790 -1220 2 0 {name=l1555 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 5790 -940 2 0 {name=l2092 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 5790 -920 2 0 {name=l2093 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 5790 -900 2 0 {name=l2094 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 5790 -880 2 0 {name=l2095 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 5790 -860 2 0 {name=l2096 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 5790 -840 2 0 {name=l2097 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 5790 -820 2 0 {name=l2098 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 5790 -800 2 0 {name=l2099 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 5790 -780 2 0 {name=l2100 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 5790 -760 2 0 {name=l2101 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 5790 -740 2 0 {name=l2102 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 5790 -720 2 0 {name=l2103 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 5790 -700 2 0 {name=l2104 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 5790 -680 2 0 {name=l2105 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 5790 -660 2 0 {name=l2106 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 5790 -640 2 0 {name=l2107 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 5790 -620 2 0 {name=l2108 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 5790 -600 2 0 {name=l2109 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 5790 -580 2 0 {name=l2110 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 5790 -560 2 0 {name=l2111 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 5790 -540 2 0 {name=l2112 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 5790 -520 2 0 {name=l2113 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 5790 -500 2 0 {name=l2114 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 5790 -480 2 0 {name=l2115 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 5790 -460 2 0 {name=l2116 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 5790 -440 2 0 {name=l2117 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 5790 -420 2 0 {name=l2118 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 5790 -400 2 0 {name=l2119 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 5790 -380 2 0 {name=l2120 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 5790 -360 2 0 {name=l2121 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 5790 -340 2 0 {name=l2122 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 5790 -320 2 0 {name=l2123 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 6320 -2790 2 0 {name=l1027 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 6320 -2770 2 0 {name=l1028 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 6320 -2750 2 0 {name=l1029 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 6320 -2730 2 0 {name=l1030 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 6320 -2710 2 0 {name=l1031 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 6320 -2690 2 0 {name=l1032 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 6320 -2670 2 0 {name=l1033 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 6320 -2650 2 0 {name=l1034 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 6320 -2630 2 0 {name=l1035 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 6320 -2610 2 0 {name=l1036 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 6320 -2590 2 0 {name=l1037 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 6320 -2570 2 0 {name=l1038 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 6320 -2550 2 0 {name=l1039 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 6320 -2530 2 0 {name=l1040 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 6320 -2510 2 0 {name=l1041 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 6320 -2490 2 0 {name=l1042 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 6320 -2470 2 0 {name=l1043 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 6320 -2450 2 0 {name=l1044 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 6320 -2430 2 0 {name=l1045 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 6320 -2410 2 0 {name=l1046 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 6320 -2390 2 0 {name=l1047 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 6320 -2370 2 0 {name=l1048 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 6320 -2350 2 0 {name=l1049 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 6320 -2330 2 0 {name=l1050 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 6320 -2310 2 0 {name=l1051 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 6320 -2290 2 0 {name=l1052 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 6320 -2270 2 0 {name=l1053 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 6320 -2250 2 0 {name=l1054 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 6320 -2230 2 0 {name=l1055 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 6320 -2210 2 0 {name=l1056 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 6320 -2190 2 0 {name=l1057 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 6320 -2170 2 0 {name=l1058 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 6330 -1840 2 0 {name=l1595 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 6330 -1820 2 0 {name=l1596 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 6330 -1800 2 0 {name=l1597 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 6330 -1780 2 0 {name=l1598 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 6330 -1760 2 0 {name=l1599 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 6330 -1740 2 0 {name=l1600 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 6330 -1720 2 0 {name=l1601 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 6330 -1700 2 0 {name=l1602 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 6330 -1680 2 0 {name=l1603 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 6330 -1660 2 0 {name=l1604 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 6330 -1640 2 0 {name=l1605 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 6330 -1620 2 0 {name=l1606 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 6330 -1600 2 0 {name=l1607 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 6330 -1580 2 0 {name=l1608 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 6330 -1560 2 0 {name=l1609 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 6330 -1540 2 0 {name=l1610 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 6330 -1520 2 0 {name=l1611 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 6330 -1500 2 0 {name=l1612 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 6330 -1480 2 0 {name=l1613 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 6330 -1460 2 0 {name=l1614 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 6330 -1440 2 0 {name=l1615 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 6330 -1420 2 0 {name=l1616 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 6330 -1400 2 0 {name=l1617 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 6330 -1380 2 0 {name=l1618 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 6330 -1360 2 0 {name=l1619 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 6330 -1340 2 0 {name=l1620 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 6330 -1320 2 0 {name=l1621 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 6330 -1300 2 0 {name=l1622 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 6330 -1280 2 0 {name=l1623 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 6330 -1260 2 0 {name=l1624 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 6330 -1240 2 0 {name=l1625 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 6330 -1220 2 0 {name=l1626 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 6330 -940 2 0 {name=l2163 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 6330 -920 2 0 {name=l2164 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 6330 -900 2 0 {name=l2165 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 6330 -880 2 0 {name=l2166 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 6330 -860 2 0 {name=l2167 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 6330 -840 2 0 {name=l2168 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 6330 -820 2 0 {name=l2169 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 6330 -800 2 0 {name=l2170 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 6330 -780 2 0 {name=l2171 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 6330 -760 2 0 {name=l2172 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 6330 -740 2 0 {name=l2173 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 6330 -720 2 0 {name=l2174 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 6330 -700 2 0 {name=l2175 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 6330 -680 2 0 {name=l2176 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 6330 -660 2 0 {name=l2177 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 6330 -640 2 0 {name=l2178 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 6330 -620 2 0 {name=l2179 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 6330 -600 2 0 {name=l2180 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 6330 -580 2 0 {name=l2181 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 6330 -560 2 0 {name=l2182 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 6330 -540 2 0 {name=l2183 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 6330 -520 2 0 {name=l2184 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 6330 -500 2 0 {name=l2185 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 6330 -480 2 0 {name=l2186 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 6330 -460 2 0 {name=l2187 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 6330 -440 2 0 {name=l2188 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 6330 -420 2 0 {name=l2189 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 6330 -400 2 0 {name=l2190 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 6330 -380 2 0 {name=l2191 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 6330 -360 2 0 {name=l2192 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 6330 -340 2 0 {name=l2193 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 6330 -320 2 0 {name=l2194 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 6840 -2790 2 0 {name=l1098 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 6840 -2770 2 0 {name=l1099 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 6840 -2750 2 0 {name=l1100 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 6840 -2730 2 0 {name=l1101 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 6840 -2710 2 0 {name=l1102 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 6840 -2690 2 0 {name=l1103 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 6840 -2670 2 0 {name=l1104 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 6840 -2650 2 0 {name=l1105 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 6840 -2630 2 0 {name=l1106 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 6840 -2610 2 0 {name=l1107 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 6840 -2590 2 0 {name=l1108 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 6840 -2570 2 0 {name=l1109 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 6840 -2550 2 0 {name=l1110 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 6840 -2530 2 0 {name=l1111 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 6840 -2510 2 0 {name=l1112 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 6840 -2490 2 0 {name=l1113 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 6840 -2470 2 0 {name=l1114 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 6840 -2450 2 0 {name=l1115 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 6840 -2430 2 0 {name=l1116 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 6840 -2410 2 0 {name=l1117 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 6840 -2390 2 0 {name=l1118 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 6840 -2370 2 0 {name=l1119 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 6840 -2350 2 0 {name=l1120 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 6840 -2330 2 0 {name=l1121 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 6840 -2310 2 0 {name=l1122 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 6840 -2290 2 0 {name=l1123 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 6840 -2270 2 0 {name=l1124 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 6840 -2250 2 0 {name=l1125 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 6840 -2230 2 0 {name=l1126 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 6840 -2210 2 0 {name=l1127 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 6840 -2190 2 0 {name=l1128 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 6840 -2170 2 0 {name=l1129 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 6850 -1840 2 0 {name=l1666 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 6850 -1820 2 0 {name=l1667 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 6850 -1800 2 0 {name=l1668 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 6850 -1780 2 0 {name=l1669 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 6850 -1760 2 0 {name=l1670 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 6850 -1740 2 0 {name=l1671 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 6850 -1720 2 0 {name=l1672 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 6850 -1700 2 0 {name=l1673 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 6850 -1680 2 0 {name=l1674 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 6850 -1660 2 0 {name=l1675 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 6850 -1640 2 0 {name=l1676 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 6850 -1620 2 0 {name=l1677 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 6850 -1600 2 0 {name=l1678 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 6850 -1580 2 0 {name=l1679 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 6850 -1560 2 0 {name=l1680 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 6850 -1540 2 0 {name=l1681 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 6850 -1520 2 0 {name=l1682 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 6850 -1500 2 0 {name=l1683 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 6850 -1480 2 0 {name=l1684 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 6850 -1460 2 0 {name=l1685 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 6850 -1440 2 0 {name=l1686 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 6850 -1420 2 0 {name=l1687 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 6850 -1400 2 0 {name=l1688 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 6850 -1380 2 0 {name=l1689 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 6850 -1360 2 0 {name=l1690 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 6850 -1340 2 0 {name=l1691 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 6850 -1320 2 0 {name=l1692 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 6850 -1300 2 0 {name=l1693 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 6850 -1280 2 0 {name=l1694 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 6850 -1260 2 0 {name=l1695 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 6850 -1240 2 0 {name=l1696 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 6850 -1220 2 0 {name=l1697 sig_type=std_logic lab=Do31}
C {lab_wire.sym} 6850 -940 2 0 {name=l2234 sig_type=std_logic lab=Do0}
C {lab_wire.sym} 6850 -920 2 0 {name=l2235 sig_type=std_logic lab=Do1}
C {lab_wire.sym} 6850 -900 2 0 {name=l2236 sig_type=std_logic lab=Do2}
C {lab_wire.sym} 6850 -880 2 0 {name=l2237 sig_type=std_logic lab=Do3}
C {lab_wire.sym} 6850 -860 2 0 {name=l2238 sig_type=std_logic lab=Do4}
C {lab_wire.sym} 6850 -840 2 0 {name=l2239 sig_type=std_logic lab=Do5}
C {lab_wire.sym} 6850 -820 2 0 {name=l2240 sig_type=std_logic lab=Do6}
C {lab_wire.sym} 6850 -800 2 0 {name=l2241 sig_type=std_logic lab=Do7}
C {lab_wire.sym} 6850 -780 2 0 {name=l2242 sig_type=std_logic lab=Do8}
C {lab_wire.sym} 6850 -760 2 0 {name=l2243 sig_type=std_logic lab=Do9}
C {lab_wire.sym} 6850 -740 2 0 {name=l2244 sig_type=std_logic lab=Do10}
C {lab_wire.sym} 6850 -720 2 0 {name=l2245 sig_type=std_logic lab=Do11}
C {lab_wire.sym} 6850 -700 2 0 {name=l2246 sig_type=std_logic lab=Do12}
C {lab_wire.sym} 6850 -680 2 0 {name=l2247 sig_type=std_logic lab=Do13}
C {lab_wire.sym} 6850 -660 2 0 {name=l2248 sig_type=std_logic lab=Do14}
C {lab_wire.sym} 6850 -640 2 0 {name=l2249 sig_type=std_logic lab=Do15}
C {lab_wire.sym} 6850 -620 2 0 {name=l2250 sig_type=std_logic lab=Do16}
C {lab_wire.sym} 6850 -600 2 0 {name=l2251 sig_type=std_logic lab=Do17}
C {lab_wire.sym} 6850 -580 2 0 {name=l2252 sig_type=std_logic lab=Do18}
C {lab_wire.sym} 6850 -560 2 0 {name=l2253 sig_type=std_logic lab=Do19}
C {lab_wire.sym} 6850 -540 2 0 {name=l2254 sig_type=std_logic lab=Do20}
C {lab_wire.sym} 6850 -520 2 0 {name=l2255 sig_type=std_logic lab=Do21}
C {lab_wire.sym} 6850 -500 2 0 {name=l2256 sig_type=std_logic lab=Do22}
C {lab_wire.sym} 6850 -480 2 0 {name=l2257 sig_type=std_logic lab=Do23}
C {lab_wire.sym} 6850 -460 2 0 {name=l2258 sig_type=std_logic lab=Do24}
C {lab_wire.sym} 6850 -440 2 0 {name=l2259 sig_type=std_logic lab=Do25}
C {lab_wire.sym} 6850 -420 2 0 {name=l2260 sig_type=std_logic lab=Do26}
C {lab_wire.sym} 6850 -400 2 0 {name=l2261 sig_type=std_logic lab=Do27}
C {lab_wire.sym} 6850 -380 2 0 {name=l2262 sig_type=std_logic lab=Do28}
C {lab_wire.sym} 6850 -360 2 0 {name=l2263 sig_type=std_logic lab=Do29}
C {lab_wire.sym} 6850 -340 2 0 {name=l2264 sig_type=std_logic lab=Do30}
C {lab_wire.sym} 6850 -320 2 0 {name=l2265 sig_type=std_logic lab=Do31}
