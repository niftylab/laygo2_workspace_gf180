v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
T {BUF_SEL} -920 -1020 0 0 2 2 {}
T {BUF_WE} -920 -1390 0 0 2 2 {}
T {SIGNALS} 60 -2500 0 0 2 2 {}
T {BUF_CLK} -2230 -590 0 0 2 2 {}
T {BUF_IN} 1040 -2400 0 0 4 4 {}
T {CLK_REG} -1280 -630 0 0 2 2 {}
T {BUF_RE} -30 -600 0 0 2 2 {}
N 770 -1170 790 -1170 {
lab=di0_buf}
N 770 -1150 790 -1150 {
lab=di1_buf}
N 770 -1130 790 -1130 {
lab=di2_buf}
N 770 -1110 790 -1110 {
lab=di3_buf}
N 770 -1090 790 -1090 {
lab=di4_buf}
N 770 -1070 790 -1070 {
lab=di5_buf}
N 770 -1050 790 -1050 {
lab=di6_buf}
N 770 -1030 790 -1030 {
lab=di7_buf}
N 770 -1010 790 -1010 {
lab=di8_buf}
N 770 -990 790 -990 {
lab=di9_buf}
N 770 -970 790 -970 {
lab=di10_buf}
N 770 -950 790 -950 {
lab=di11_buf}
N 770 -930 790 -930 {
lab=di12_buf}
N 770 -910 790 -910 {
lab=di13_buf}
N 770 -890 790 -890 {
lab=di14_buf}
N 770 -870 790 -870 {
lab=di15_buf}
N 770 -850 790 -850 {
lab=di16_buf}
N 770 -830 790 -830 {
lab=di17_buf}
N 770 -810 790 -810 {
lab=di18_buf}
N 770 -790 790 -790 {
lab=di19_buf}
N 770 -770 790 -770 {
lab=di20_buf}
N 770 -750 790 -750 {
lab=di21_buf}
N 770 -730 790 -730 {
lab=di22_buf}
N 770 -710 790 -710 {
lab=di23_buf}
N 770 -690 790 -690 {
lab=di24_buf}
N 770 -670 790 -670 {
lab=di25_buf}
N 770 -650 790 -650 {
lab=di26_buf}
N 770 -630 790 -630 {
lab=di27_buf}
N 770 -610 790 -610 {
lab=di28_buf}
N 770 -590 790 -590 {
lab=di29_buf}
N 770 -570 790 -570 {
lab=di30_buf}
N 770 -550 790 -550 {
lab=di31_buf}
N 820 -1260 820 -1240 {
lab=CLK_buf}
N 920 -1260 920 -1240 {
lab=we0_buf}
N 940 -1260 940 -1240 {
lab=we1_buf}
N 960 -1260 960 -1240 {
lab=we2_buf}
N 980 -1260 980 -1240 {
lab=we3_buf}
N 1020 -1260 1020 -1240 {
lab=VDD}
N 1040 -1260 1040 -1240 {
lab=VSS}
N 840 -1260 840 -1240 {
lab=ram1}
N 1300 -1170 1320 -1170 {
lab=di0_buf}
N 1300 -1150 1320 -1150 {
lab=di1_buf}
N 1300 -1130 1320 -1130 {
lab=di2_buf}
N 1300 -1110 1320 -1110 {
lab=di3_buf}
N 1300 -1090 1320 -1090 {
lab=di4_buf}
N 1300 -1070 1320 -1070 {
lab=di5_buf}
N 1300 -1050 1320 -1050 {
lab=di6_buf}
N 1300 -1030 1320 -1030 {
lab=di7_buf}
N 1300 -1010 1320 -1010 {
lab=di8_buf}
N 1300 -990 1320 -990 {
lab=di9_buf}
N 1300 -970 1320 -970 {
lab=di10_buf}
N 1300 -950 1320 -950 {
lab=di11_buf}
N 1300 -930 1320 -930 {
lab=di12_buf}
N 1300 -910 1320 -910 {
lab=di13_buf}
N 1300 -890 1320 -890 {
lab=di14_buf}
N 1300 -870 1320 -870 {
lab=di15_buf}
N 1300 -850 1320 -850 {
lab=di16_buf}
N 1300 -830 1320 -830 {
lab=di17_buf}
N 1300 -810 1320 -810 {
lab=di18_buf}
N 1300 -790 1320 -790 {
lab=di19_buf}
N 1300 -770 1320 -770 {
lab=di20_buf}
N 1300 -750 1320 -750 {
lab=di21_buf}
N 1300 -730 1320 -730 {
lab=di22_buf}
N 1300 -710 1320 -710 {
lab=di23_buf}
N 1300 -690 1320 -690 {
lab=di24_buf}
N 1300 -670 1320 -670 {
lab=di25_buf}
N 1300 -650 1320 -650 {
lab=di26_buf}
N 1300 -630 1320 -630 {
lab=di27_buf}
N 1300 -610 1320 -610 {
lab=di28_buf}
N 1300 -590 1320 -590 {
lab=di29_buf}
N 1300 -570 1320 -570 {
lab=di30_buf}
N 1300 -550 1320 -550 {
lab=di31_buf}
N 1350 -1260 1350 -1240 {
lab=CLK_buf}
N 1470 -1260 1470 -1240 {
lab=we1_buf}
N 1490 -1260 1490 -1240 {
lab=we2_buf}
N 1510 -1260 1510 -1240 {
lab=we3_buf}
N 1550 -1260 1550 -1240 {
lab=VDD}
N 1570 -1260 1570 -1240 {
lab=VSS}
N 1370 -1260 1370 -1240 {
lab=ram2}
N 1840 -1170 1860 -1170 {
lab=di0_buf}
N 1840 -1150 1860 -1150 {
lab=di1_buf}
N 1840 -1130 1860 -1130 {
lab=di2_buf}
N 1840 -1110 1860 -1110 {
lab=di3_buf}
N 1840 -1090 1860 -1090 {
lab=di4_buf}
N 1840 -1070 1860 -1070 {
lab=di5_buf}
N 1840 -1050 1860 -1050 {
lab=di6_buf}
N 1840 -1030 1860 -1030 {
lab=di7_buf}
N 1840 -1010 1860 -1010 {
lab=di8_buf}
N 1840 -990 1860 -990 {
lab=di9_buf}
N 1840 -970 1860 -970 {
lab=di10_buf}
N 1840 -950 1860 -950 {
lab=di11_buf}
N 1840 -930 1860 -930 {
lab=di12_buf}
N 1840 -910 1860 -910 {
lab=di13_buf}
N 1840 -890 1860 -890 {
lab=di14_buf}
N 1840 -870 1860 -870 {
lab=di15_buf}
N 1840 -850 1860 -850 {
lab=di16_buf}
N 1840 -830 1860 -830 {
lab=di17_buf}
N 1840 -810 1860 -810 {
lab=di18_buf}
N 1840 -790 1860 -790 {
lab=di19_buf}
N 1840 -770 1860 -770 {
lab=di20_buf}
N 1840 -750 1860 -750 {
lab=di21_buf}
N 1840 -730 1860 -730 {
lab=di22_buf}
N 1840 -710 1860 -710 {
lab=di23_buf}
N 1840 -690 1860 -690 {
lab=di24_buf}
N 1840 -670 1860 -670 {
lab=di25_buf}
N 1840 -650 1860 -650 {
lab=di26_buf}
N 1840 -630 1860 -630 {
lab=di27_buf}
N 1840 -610 1860 -610 {
lab=di28_buf}
N 1840 -590 1860 -590 {
lab=di29_buf}
N 1840 -570 1860 -570 {
lab=di30_buf}
N 1840 -550 1860 -550 {
lab=di31_buf}
N 1890 -1260 1890 -1240 {
lab=CLK_buf}
N 2010 -1260 2010 -1240 {
lab=we1_buf}
N 2030 -1260 2030 -1240 {
lab=we2_buf}
N 2050 -1260 2050 -1240 {
lab=we3_buf}
N 2090 -1260 2090 -1240 {
lab=VDD}
N 2110 -1260 2110 -1240 {
lab=VSS}
N 1910 -1260 1910 -1240 {
lab=ram3}
N 2360 -1170 2380 -1170 {
lab=di0_buf}
N 2360 -1150 2380 -1150 {
lab=di1_buf}
N 2360 -1130 2380 -1130 {
lab=di2_buf}
N 2360 -1110 2380 -1110 {
lab=di3_buf}
N 2360 -1090 2380 -1090 {
lab=di4_buf}
N 2360 -1070 2380 -1070 {
lab=di5_buf}
N 2360 -1050 2380 -1050 {
lab=di6_buf}
N 2360 -1030 2380 -1030 {
lab=di7_buf}
N 2360 -1010 2380 -1010 {
lab=di8_buf}
N 2360 -990 2380 -990 {
lab=di9_buf}
N 2360 -970 2380 -970 {
lab=di10_buf}
N 2360 -950 2380 -950 {
lab=di11_buf}
N 2360 -930 2380 -930 {
lab=di12_buf}
N 2360 -910 2380 -910 {
lab=di13_buf}
N 2360 -890 2380 -890 {
lab=di14_buf}
N 2360 -870 2380 -870 {
lab=di15_buf}
N 2360 -850 2380 -850 {
lab=di16_buf}
N 2360 -830 2380 -830 {
lab=di17_buf}
N 2360 -810 2380 -810 {
lab=di18_buf}
N 2360 -790 2380 -790 {
lab=di19_buf}
N 2360 -770 2380 -770 {
lab=di20_buf}
N 2360 -750 2380 -750 {
lab=di21_buf}
N 2360 -730 2380 -730 {
lab=di22_buf}
N 2360 -710 2380 -710 {
lab=di23_buf}
N 2360 -690 2380 -690 {
lab=di24_buf}
N 2360 -670 2380 -670 {
lab=di25_buf}
N 2360 -650 2380 -650 {
lab=di26_buf}
N 2360 -630 2380 -630 {
lab=di27_buf}
N 2360 -610 2380 -610 {
lab=di28_buf}
N 2360 -590 2380 -590 {
lab=di29_buf}
N 2360 -570 2380 -570 {
lab=di30_buf}
N 2360 -550 2380 -550 {
lab=di31_buf}
N 2410 -1260 2410 -1240 {
lab=CLK_buf}
N 2510 -1260 2510 -1240 {
lab=we0_buf}
N 2530 -1260 2530 -1240 {
lab=we1_buf}
N 2550 -1260 2550 -1240 {
lab=we2_buf}
N 2570 -1260 2570 -1240 {
lab=we3_buf}
N 2610 -1260 2610 -1240 {
lab=VDD}
N 2630 -1260 2630 -1240 {
lab=VSS}
N 2430 -1260 2430 -1240 {
lab=ram4}
N 1990 -1260 1990 -1240 {
lab=we0_buf}
N 1450 -1260 1450 -1240 {
lab=we0_buf}
N 860 -1260 860 -1240 {
lab=A0_buf}
N 880 -1260 880 -1240 {
lab=A1_buf}
N 900 -1260 900 -1240 {
lab=A2_buf}
N 1390 -1260 1390 -1240 {
lab=A0_buf}
N 1410 -1260 1410 -1240 {
lab=A1_buf}
N 1430 -1260 1430 -1240 {
lab=A2_buf}
N 1930 -1260 1930 -1240 {
lab=A0_buf}
N 1950 -1260 1950 -1240 {
lab=A1_buf}
N 1970 -1260 1970 -1240 {
lab=A2_buf}
N 2450 -1260 2450 -1240 {
lab=A0_buf}
N 2470 -1260 2470 -1240 {
lab=A1_buf}
N 2490 -1260 2490 -1240 {
lab=A2_buf}
N 1090 -1170 1110 -1170 {
lab=ram1_do0}
N 1090 -1150 1110 -1150 {
lab=ram1_do1}
N 1090 -1130 1110 -1130 {
lab=ram1_do2}
N 1090 -1110 1110 -1110 {
lab=ram1_do3}
N 1090 -1090 1110 -1090 {
lab=ram1_do4}
N 1090 -1070 1110 -1070 {
lab=ram1_do5}
N 1090 -1050 1110 -1050 {
lab=ram1_do6}
N 1090 -1030 1110 -1030 {
lab=ram1_do7}
N 1090 -1010 1110 -1010 {
lab=ram1_do8}
N 1090 -990 1110 -990 {
lab=ram1_do9}
N 1090 -970 1110 -970 {
lab=ram1_do10}
N 1090 -950 1110 -950 {
lab=ram1_do11}
N 1090 -930 1110 -930 {
lab=ram1_do12}
N 1090 -910 1110 -910 {
lab=ram1_do13}
N 1090 -890 1110 -890 {
lab=ram1_do14}
N 1090 -870 1110 -870 {
lab=ram1_do15}
N 1090 -850 1110 -850 {
lab=ram1_do16}
N 1090 -830 1110 -830 {
lab=ram1_do17}
N 1090 -810 1110 -810 {
lab=ram1_do18}
N 1090 -790 1110 -790 {
lab=ram1_do19}
N 1090 -770 1110 -770 {
lab=ram1_do20}
N 1090 -750 1110 -750 {
lab=ram1_do21}
N 1090 -730 1110 -730 {
lab=ram1_do22}
N 1090 -710 1110 -710 {
lab=ram1_do23}
N 1090 -690 1110 -690 {
lab=ram1_do24}
N 1090 -670 1110 -670 {
lab=ram1_do25}
N 1090 -650 1110 -650 {
lab=ram1_do26}
N 1090 -630 1110 -630 {
lab=ram1_do27}
N 1090 -610 1110 -610 {
lab=ram1_do28}
N 1090 -590 1110 -590 {
lab=ram1_do29}
N 1090 -570 1110 -570 {
lab=ram1_do30}
N 1090 -550 1110 -550 {
lab=ram1_do31}
N 1620 -1170 1640 -1170 {
lab=ram2_do0}
N 1620 -1150 1640 -1150 {
lab=ram2_do1}
N 1620 -1130 1640 -1130 {
lab=ram2_do2}
N 1620 -1110 1640 -1110 {
lab=ram2_do3}
N 1620 -1090 1640 -1090 {
lab=ram2_do4}
N 1620 -1070 1640 -1070 {
lab=ram2_do5}
N 1620 -1050 1640 -1050 {
lab=ram2_do6}
N 1620 -1030 1640 -1030 {
lab=ram2_do7}
N 1620 -1010 1640 -1010 {
lab=ram2_do8}
N 1620 -990 1640 -990 {
lab=ram2_do9}
N 1620 -970 1640 -970 {
lab=ram2_do10}
N 1620 -950 1640 -950 {
lab=ram2_do11}
N 1620 -930 1640 -930 {
lab=ram2_do12}
N 1620 -910 1640 -910 {
lab=ram2_do13}
N 1620 -890 1640 -890 {
lab=ram2_do14}
N 1620 -870 1640 -870 {
lab=ram2_do15}
N 1620 -850 1640 -850 {
lab=ram2_do16}
N 1620 -830 1640 -830 {
lab=ram2_do17}
N 1620 -810 1640 -810 {
lab=ram2_do18}
N 1620 -790 1640 -790 {
lab=ram2_do19}
N 1620 -770 1640 -770 {
lab=ram2_do20}
N 1620 -750 1640 -750 {
lab=ram2_do21}
N 1620 -730 1640 -730 {
lab=ram2_do22}
N 1620 -710 1640 -710 {
lab=ram2_do23}
N 1620 -690 1640 -690 {
lab=ram2_do24}
N 1620 -670 1640 -670 {
lab=ram2_do25}
N 1620 -650 1640 -650 {
lab=ram2_do26}
N 1620 -630 1640 -630 {
lab=ram2_do27}
N 1620 -610 1640 -610 {
lab=ram2_do28}
N 1620 -590 1640 -590 {
lab=ram2_do29}
N 1620 -570 1640 -570 {
lab=ram2_do30}
N 1620 -550 1640 -550 {
lab=ram2_do31}
N 2160 -1170 2180 -1170 {
lab=ram3_do0}
N 2160 -1150 2180 -1150 {
lab=ram3_do1}
N 2160 -1130 2180 -1130 {
lab=ram3_do2}
N 2160 -1110 2180 -1110 {
lab=ram3_do3}
N 2160 -1090 2180 -1090 {
lab=ram3_do4}
N 2160 -1070 2180 -1070 {
lab=ram3_do5}
N 2160 -1050 2180 -1050 {
lab=ram3_do6}
N 2160 -1030 2180 -1030 {
lab=ram3_do7}
N 2160 -1010 2180 -1010 {
lab=ram3_do8}
N 2160 -990 2180 -990 {
lab=ram3_do9}
N 2160 -970 2180 -970 {
lab=ram3_do10}
N 2160 -950 2180 -950 {
lab=ram3_do11}
N 2160 -930 2180 -930 {
lab=ram3_do12}
N 2160 -910 2180 -910 {
lab=ram3_do13}
N 2160 -890 2180 -890 {
lab=ram3_do14}
N 2160 -870 2180 -870 {
lab=ram3_do15}
N 2160 -850 2180 -850 {
lab=ram3_do16}
N 2160 -830 2180 -830 {
lab=ram3_do17}
N 2160 -810 2180 -810 {
lab=ram3_do18}
N 2160 -790 2180 -790 {
lab=ram3_do19}
N 2160 -770 2180 -770 {
lab=ram3_do20}
N 2160 -750 2180 -750 {
lab=ram3_do21}
N 2160 -730 2180 -730 {
lab=ram3_do22}
N 2160 -710 2180 -710 {
lab=ram3_do23}
N 2160 -690 2180 -690 {
lab=ram3_do24}
N 2160 -670 2180 -670 {
lab=ram3_do25}
N 2160 -650 2180 -650 {
lab=ram3_do26}
N 2160 -630 2180 -630 {
lab=ram3_do27}
N 2160 -610 2180 -610 {
lab=ram3_do28}
N 2160 -590 2180 -590 {
lab=ram3_do29}
N 2160 -570 2180 -570 {
lab=ram3_do30}
N 2160 -550 2180 -550 {
lab=ram3_do31}
N 2680 -1170 2700 -1170 {
lab=ram4_do0}
N 2680 -1150 2700 -1150 {
lab=ram4_do1}
N 2680 -1130 2700 -1130 {
lab=ram4_do2}
N 2680 -1110 2700 -1110 {
lab=ram4_do3}
N 2680 -1090 2700 -1090 {
lab=ram4_do4}
N 2680 -1070 2700 -1070 {
lab=ram4_do5}
N 2680 -1050 2700 -1050 {
lab=ram4_do6}
N 2680 -1030 2700 -1030 {
lab=ram4_do7}
N 2680 -1010 2700 -1010 {
lab=ram4_do8}
N 2680 -990 2700 -990 {
lab=ram4_do9}
N 2680 -970 2700 -970 {
lab=ram4_do10}
N 2680 -950 2700 -950 {
lab=ram4_do11}
N 2680 -930 2700 -930 {
lab=ram4_do12}
N 2680 -910 2700 -910 {
lab=ram4_do13}
N 2680 -890 2700 -890 {
lab=ram4_do14}
N 2680 -870 2700 -870 {
lab=ram4_do15}
N 2680 -850 2700 -850 {
lab=ram4_do16}
N 2680 -830 2700 -830 {
lab=ram4_do17}
N 2680 -810 2700 -810 {
lab=ram4_do18}
N 2680 -790 2700 -790 {
lab=ram4_do19}
N 2680 -770 2700 -770 {
lab=ram4_do20}
N 2680 -750 2700 -750 {
lab=ram4_do21}
N 2680 -730 2700 -730 {
lab=ram4_do22}
N 2680 -710 2700 -710 {
lab=ram4_do23}
N 2680 -690 2700 -690 {
lab=ram4_do24}
N 2680 -670 2700 -670 {
lab=ram4_do25}
N 2680 -650 2700 -650 {
lab=ram4_do26}
N 2680 -630 2700 -630 {
lab=ram4_do27}
N 2680 -610 2700 -610 {
lab=ram4_do28}
N 2680 -590 2700 -590 {
lab=ram4_do29}
N 2680 -570 2700 -570 {
lab=ram4_do30}
N 2680 -550 2700 -550 {
lab=ram4_do31}
N -1760 -810 -1730 -810 {
lab=A3}
N -1760 -790 -1730 -790 {
lab=A4}
N -3760 0 -3760 40 {
lab=ram1_do0}
N -3740 0 -3740 40 {
lab=ram2_do0}
N -3720 0 -3720 40 {
lab=ram3_do0}
N -3700 0 -3700 40 {
lab=ram4_do0}
N -3600 270 -3600 360 {
lab=do0}
N -3370 0 -3370 40 {
lab=ram1_do1}
N -3350 0 -3350 40 {
lab=ram2_do1}
N -3330 0 -3330 40 {
lab=ram3_do1}
N -3310 0 -3310 40 {
lab=ram4_do1}
N -3210 270 -3210 360 {
lab=do1}
N -2980 0 -2980 40 {
lab=ram1_do2}
N -2960 0 -2960 40 {
lab=ram2_do2}
N -2940 0 -2940 40 {
lab=ram3_do2}
N -2920 0 -2920 40 {
lab=ram4_do2}
N -2820 270 -2820 360 {
lab=do2}
N -2590 0 -2590 40 {
lab=ram1_do3}
N -2570 0 -2570 40 {
lab=ram2_do3}
N -2550 0 -2550 40 {
lab=ram3_do3}
N -2530 0 -2530 40 {
lab=ram4_do3}
N -2430 270 -2430 360 {
lab=do3}
N -2200 0 -2200 40 {
lab=ram1_do4}
N -2180 0 -2180 40 {
lab=ram2_do4}
N -2160 0 -2160 40 {
lab=ram3_do4}
N -2140 0 -2140 40 {
lab=ram4_do4}
N -2040 270 -2040 360 {
lab=do4}
N -1810 0 -1810 40 {
lab=ram1_do5}
N -1790 0 -1790 40 {
lab=ram2_do5}
N -1770 0 -1770 40 {
lab=ram3_do5}
N -1750 0 -1750 40 {
lab=ram4_do5}
N -1650 270 -1650 360 {
lab=do5}
N -1420 0 -1420 40 {
lab=ram1_do6}
N -1400 0 -1400 40 {
lab=ram2_do6}
N -1380 0 -1380 40 {
lab=ram3_do6}
N -1360 0 -1360 40 {
lab=ram4_do6}
N -1260 270 -1260 360 {
lab=do6}
N -1030 0 -1030 40 {
lab=ram1_do7}
N -1010 0 -1010 40 {
lab=ram2_do7}
N -990 0 -990 40 {
lab=ram3_do7}
N -970 0 -970 40 {
lab=ram4_do7}
N -870 270 -870 360 {
lab=do7}
N -640 0 -640 40 {
lab=ram1_do8}
N -620 0 -620 40 {
lab=ram2_do8}
N -600 0 -600 40 {
lab=ram3_do8}
N -580 0 -580 40 {
lab=ram4_do8}
N -480 270 -480 360 {
lab=do8}
N -250 0 -250 40 {
lab=ram1_do9}
N -230 0 -230 40 {
lab=ram2_do9}
N -210 0 -210 40 {
lab=ram3_do9}
N -190 0 -190 40 {
lab=ram4_do9}
N -90 270 -90 360 {
lab=do9}
N 140 0 140 40 {
lab=ram1_do10}
N 160 0 160 40 {
lab=ram2_do10}
N 180 0 180 40 {
lab=ram3_do10}
N 200 0 200 40 {
lab=ram4_do10}
N 300 270 300 360 {
lab=do10}
N 530 0 530 40 {
lab=ram1_do11}
N 550 0 550 40 {
lab=ram2_do11}
N 570 0 570 40 {
lab=ram3_do11}
N 590 0 590 40 {
lab=ram4_do11}
N 690 270 690 360 {
lab=do11}
N 920 0 920 40 {
lab=ram1_do12}
N 940 0 940 40 {
lab=ram2_do12}
N 960 0 960 40 {
lab=ram3_do12}
N 980 0 980 40 {
lab=ram4_do12}
N 1080 270 1080 360 {
lab=do12}
N 1310 0 1310 40 {
lab=ram1_do13}
N 1330 0 1330 40 {
lab=ram2_do13}
N 1350 0 1350 40 {
lab=ram3_do13}
N 1370 0 1370 40 {
lab=ram4_do13}
N 1470 270 1470 360 {
lab=do13}
N 1700 0 1700 40 {
lab=ram1_do14}
N 1720 0 1720 40 {
lab=ram2_do14}
N 1740 0 1740 40 {
lab=ram3_do14}
N 1760 0 1760 40 {
lab=ram4_do14}
N 1860 270 1860 360 {
lab=do14}
N 2090 0 2090 40 {
lab=ram1_do15}
N 2110 0 2110 40 {
lab=ram2_do15}
N 2130 0 2130 40 {
lab=ram3_do15}
N 2150 0 2150 40 {
lab=ram4_do15}
N 2250 270 2250 360 {
lab=do15}
N 2480 0 2480 40 {
lab=ram1_do16}
N 2500 0 2500 40 {
lab=ram2_do16}
N 2520 0 2520 40 {
lab=ram3_do16}
N 2540 0 2540 40 {
lab=ram4_do16}
N 2640 270 2640 360 {
lab=do16}
N 2870 0 2870 40 {
lab=ram1_do17}
N 2890 0 2890 40 {
lab=ram2_do17}
N 2910 0 2910 40 {
lab=ram3_do17}
N 2930 0 2930 40 {
lab=ram4_do17}
N 3030 270 3030 360 {
lab=do17}
N 3260 0 3260 40 {
lab=ram1_do18}
N 3280 0 3280 40 {
lab=ram2_do18}
N 3300 0 3300 40 {
lab=ram3_do18}
N 3320 0 3320 40 {
lab=ram4_do18}
N 3420 270 3420 360 {
lab=do18}
N 3650 0 3650 40 {
lab=ram1_do19}
N 3670 0 3670 40 {
lab=ram2_do19}
N 3690 0 3690 40 {
lab=ram3_do19}
N 3710 0 3710 40 {
lab=ram4_do19}
N 3810 270 3810 360 {
lab=do19}
N 4040 0 4040 40 {
lab=ram1_do20}
N 4060 0 4060 40 {
lab=ram2_do20}
N 4080 0 4080 40 {
lab=ram3_do20}
N 4100 0 4100 40 {
lab=ram4_do20}
N 4200 270 4200 360 {
lab=do20}
N 4430 0 4430 40 {
lab=ram1_do21}
N 4450 0 4450 40 {
lab=ram2_do21}
N 4470 0 4470 40 {
lab=ram3_do21}
N 4490 0 4490 40 {
lab=ram4_do21}
N 4590 270 4590 360 {
lab=do21}
N 4820 0 4820 40 {
lab=ram1_do22}
N 4840 0 4840 40 {
lab=ram2_do22}
N 4860 0 4860 40 {
lab=ram3_do22}
N 4880 0 4880 40 {
lab=ram4_do22}
N 4980 270 4980 360 {
lab=do22}
N 5210 0 5210 40 {
lab=ram1_do23}
N 5230 0 5230 40 {
lab=ram2_do23}
N 5250 0 5250 40 {
lab=ram3_do23}
N 5270 0 5270 40 {
lab=ram4_do23}
N 5370 270 5370 360 {
lab=do23}
N 5600 0 5600 40 {
lab=ram1_do24}
N 5620 0 5620 40 {
lab=ram2_do24}
N 5640 0 5640 40 {
lab=ram3_do24}
N 5660 0 5660 40 {
lab=ram4_do24}
N 5760 270 5760 360 {
lab=do24}
N 5990 0 5990 40 {
lab=ram1_do25}
N 6010 0 6010 40 {
lab=ram2_do25}
N 6030 0 6030 40 {
lab=ram3_do25}
N 6050 0 6050 40 {
lab=ram4_do25}
N 6150 270 6150 360 {
lab=do25}
N 6380 0 6380 40 {
lab=ram1_do26}
N 6400 0 6400 40 {
lab=ram2_do26}
N 6420 0 6420 40 {
lab=ram3_do26}
N 6440 0 6440 40 {
lab=ram4_do26}
N 6540 270 6540 360 {
lab=do26}
N 6770 0 6770 40 {
lab=ram1_do27}
N 6790 0 6790 40 {
lab=ram2_do27}
N 6810 0 6810 40 {
lab=ram3_do27}
N 6830 0 6830 40 {
lab=ram4_do27}
N 6930 270 6930 360 {
lab=do27}
N 7160 0 7160 40 {
lab=ram1_do28}
N 7180 0 7180 40 {
lab=ram2_do28}
N 7200 0 7200 40 {
lab=ram3_do28}
N 7220 0 7220 40 {
lab=ram4_do28}
N 7320 270 7320 360 {
lab=do28}
N 7550 0 7550 40 {
lab=ram1_do29}
N 7570 0 7570 40 {
lab=ram2_do29}
N 7590 0 7590 40 {
lab=ram3_do29}
N 7610 0 7610 40 {
lab=ram4_do29}
N 7710 270 7710 360 {
lab=do29}
N 7940 0 7940 40 {
lab=ram1_do30}
N 7960 0 7960 40 {
lab=ram2_do30}
N 7980 0 7980 40 {
lab=ram3_do30}
N 8000 0 8000 40 {
lab=ram4_do30}
N 8100 270 8100 360 {
lab=do30}
N 8330 0 8330 40 {
lab=ram1_do31}
N 8350 0 8350 40 {
lab=ram2_do31}
N 8370 0 8370 40 {
lab=ram3_do31}
N 8390 0 8390 40 {
lab=ram4_do31}
N 8490 270 8490 360 {
lab=do31}
N -3730 150 -3730 230 {
lab=muxout0}
N -3670 180 -3670 190 {
lab=VDD}
N -3680 310 -3670 310 {
lab=VSS}
N -3750 270 -3730 270 {
lab=ck_gated}
N -3670 120 -3650 120 {
lab=VSS}
N -3810 120 -3790 120 {
lab=VDD}
N -3850 70 -3820 70 {
lab=A3_buf}
N -3850 90 -3820 90 {
lab=A4_buf}
N -3640 70 -3610 70 {
lab=A3_bar}
N -3640 90 -3610 90 {
lab=A4_bar}
N -3340 150 -3340 230 {
lab=muxout1}
N -3280 180 -3280 190 {
lab=VDD}
N -3290 310 -3280 310 {
lab=VSS}
N -3360 270 -3340 270 {
lab=ck_gated}
N -3280 120 -3260 120 {
lab=VSS}
N -3420 120 -3400 120 {
lab=VDD}
N -3460 70 -3430 70 {
lab=A3_buf}
N -3460 90 -3430 90 {
lab=A4_buf}
N -3250 70 -3220 70 {
lab=A3_bar}
N -3250 90 -3220 90 {
lab=A4_bar}
N -2950 150 -2950 230 {
lab=muxout2}
N -2890 180 -2890 190 {
lab=VDD}
N -2900 310 -2890 310 {
lab=VSS}
N -2970 270 -2950 270 {
lab=ck_gated}
N -2890 120 -2870 120 {
lab=VSS}
N -3030 120 -3010 120 {
lab=VDD}
N -3070 70 -3040 70 {
lab=A3_buf}
N -3070 90 -3040 90 {
lab=A4_buf}
N -2860 70 -2830 70 {
lab=A3_bar}
N -2860 90 -2830 90 {
lab=A4_bar}
N -2560 150 -2560 230 {
lab=muxout3}
N -2500 180 -2500 190 {
lab=VDD}
N -2510 310 -2500 310 {
lab=VSS}
N -2580 270 -2560 270 {
lab=ck_gated}
N -2500 120 -2480 120 {
lab=VSS}
N -2640 120 -2620 120 {
lab=VDD}
N -2680 70 -2650 70 {
lab=A3_buf}
N -2680 90 -2650 90 {
lab=A4_buf}
N -2470 70 -2440 70 {
lab=A3_bar}
N -2470 90 -2440 90 {
lab=A4_bar}
N -2170 150 -2170 230 {
lab=muxout4}
N -2110 180 -2110 190 {
lab=VDD}
N -2120 310 -2110 310 {
lab=VSS}
N -2190 270 -2170 270 {
lab=ck_gated}
N -2110 120 -2090 120 {
lab=VSS}
N -2250 120 -2230 120 {
lab=VDD}
N -2290 70 -2260 70 {
lab=A3_buf}
N -2290 90 -2260 90 {
lab=A4_buf}
N -2080 70 -2050 70 {
lab=A3_bar}
N -2080 90 -2050 90 {
lab=A4_bar}
N -1780 150 -1780 230 {
lab=muxout5}
N -1720 180 -1720 190 {
lab=VDD}
N -1730 310 -1720 310 {
lab=VSS}
N -1800 270 -1780 270 {
lab=ck_gated}
N -1720 120 -1700 120 {
lab=VSS}
N -1860 120 -1840 120 {
lab=VDD}
N -1900 70 -1870 70 {
lab=A3_buf}
N -1900 90 -1870 90 {
lab=A4_buf}
N -1690 70 -1660 70 {
lab=A3_bar}
N -1690 90 -1660 90 {
lab=A4_bar}
N -1390 150 -1390 230 {
lab=muxout6}
N -1330 180 -1330 190 {
lab=VDD}
N -1340 310 -1330 310 {
lab=VSS}
N -1410 270 -1390 270 {
lab=ck_gated}
N -1330 120 -1310 120 {
lab=VSS}
N -1470 120 -1450 120 {
lab=VDD}
N -1510 70 -1480 70 {
lab=A3_buf}
N -1510 90 -1480 90 {
lab=A4_buf}
N -1300 70 -1270 70 {
lab=A3_bar}
N -1300 90 -1270 90 {
lab=A4_bar}
N -1000 150 -1000 230 {
lab=muxout7}
N -940 180 -940 190 {
lab=VDD}
N -950 310 -940 310 {
lab=VSS}
N -1020 270 -1000 270 {
lab=ck_gated}
N -940 120 -920 120 {
lab=VSS}
N -1080 120 -1060 120 {
lab=VDD}
N -1120 70 -1090 70 {
lab=A3_buf}
N -1120 90 -1090 90 {
lab=A4_buf}
N -910 70 -880 70 {
lab=A3_bar}
N -910 90 -880 90 {
lab=A4_bar}
N -610 150 -610 230 {
lab=#net1}
N -550 180 -550 190 {
lab=VDD}
N -560 310 -550 310 {
lab=VSS}
N -630 270 -610 270 {
lab=ck_gated}
N -550 120 -530 120 {
lab=VSS}
N -690 120 -670 120 {
lab=VDD}
N -730 70 -700 70 {
lab=A3_buf}
N -730 90 -700 90 {
lab=A4_buf}
N -520 70 -490 70 {
lab=A3_bar}
N -520 90 -490 90 {
lab=A4_bar}
N -220 150 -220 230 {
lab=#net2}
N -160 180 -160 190 {
lab=VDD}
N -170 310 -160 310 {
lab=VSS}
N -240 270 -220 270 {
lab=ck_gated}
N -160 120 -140 120 {
lab=VSS}
N -300 120 -280 120 {
lab=VDD}
N -340 70 -310 70 {
lab=A3_buf}
N -340 90 -310 90 {
lab=A4_buf}
N -130 70 -100 70 {
lab=A3_bar}
N -130 90 -100 90 {
lab=A4_bar}
N 170 150 170 230 {
lab=#net3}
N 230 180 230 190 {
lab=VDD}
N 220 310 230 310 {
lab=VSS}
N 150 270 170 270 {
lab=ck_gated}
N 230 120 250 120 {
lab=VSS}
N 90 120 110 120 {
lab=VDD}
N 50 70 80 70 {
lab=A3_buf}
N 50 90 80 90 {
lab=A4_buf}
N 260 70 290 70 {
lab=A3_bar}
N 260 90 290 90 {
lab=A4_bar}
N 560 150 560 230 {
lab=#net4}
N 620 180 620 190 {
lab=VDD}
N 610 310 620 310 {
lab=VSS}
N 540 270 560 270 {
lab=ck_gated}
N 620 120 640 120 {
lab=VSS}
N 480 120 500 120 {
lab=VDD}
N 440 70 470 70 {
lab=A3_buf}
N 440 90 470 90 {
lab=A4_buf}
N 650 70 680 70 {
lab=A3_bar}
N 650 90 680 90 {
lab=A4_bar}
N 950 150 950 230 {
lab=#net5}
N 1010 180 1010 190 {
lab=VDD}
N 1000 310 1010 310 {
lab=VSS}
N 930 270 950 270 {
lab=ck_gated}
N 1010 120 1030 120 {
lab=VSS}
N 870 120 890 120 {
lab=VDD}
N 830 70 860 70 {
lab=A3_buf}
N 830 90 860 90 {
lab=A4_buf}
N 1040 70 1070 70 {
lab=A3_bar}
N 1040 90 1070 90 {
lab=A4_bar}
N 1340 150 1340 230 {
lab=#net6}
N 1400 180 1400 190 {
lab=VDD}
N 1390 310 1400 310 {
lab=VSS}
N 1320 270 1340 270 {
lab=ck_gated}
N 1400 120 1420 120 {
lab=VSS}
N 1260 120 1280 120 {
lab=VDD}
N 1220 70 1250 70 {
lab=A3_buf}
N 1220 90 1250 90 {
lab=A4_buf}
N 1430 70 1460 70 {
lab=A3_bar}
N 1430 90 1460 90 {
lab=A4_bar}
N 1730 150 1730 230 {
lab=#net7}
N 1790 180 1790 190 {
lab=VDD}
N 1780 310 1790 310 {
lab=VSS}
N 1710 270 1730 270 {
lab=ck_gated}
N 1790 120 1810 120 {
lab=VSS}
N 1650 120 1670 120 {
lab=VDD}
N 1610 70 1640 70 {
lab=A3_buf}
N 1610 90 1640 90 {
lab=A4_buf}
N 1820 70 1850 70 {
lab=A3_bar}
N 1820 90 1850 90 {
lab=A4_bar}
N 2120 150 2120 230 {
lab=#net8}
N 2180 180 2180 190 {
lab=VDD}
N 2170 310 2180 310 {
lab=VSS}
N 2100 270 2120 270 {
lab=ck_gated}
N 2180 120 2200 120 {
lab=VSS}
N 2040 120 2060 120 {
lab=VDD}
N 2000 70 2030 70 {
lab=A3_buf}
N 2000 90 2030 90 {
lab=A4_buf}
N 2210 70 2240 70 {
lab=A3_bar}
N 2210 90 2240 90 {
lab=A4_bar}
N 2510 150 2510 230 {
lab=#net9}
N 2570 180 2570 190 {
lab=VDD}
N 2560 310 2570 310 {
lab=VSS}
N 2490 270 2510 270 {
lab=ck_gated}
N 2570 120 2590 120 {
lab=VSS}
N 2430 120 2450 120 {
lab=VDD}
N 2390 70 2420 70 {
lab=A3_buf}
N 2390 90 2420 90 {
lab=A4_buf}
N 2600 70 2630 70 {
lab=A3_bar}
N 2600 90 2630 90 {
lab=A4_bar}
N 2900 150 2900 230 {
lab=#net10}
N 2960 180 2960 190 {
lab=VDD}
N 2950 310 2960 310 {
lab=VSS}
N 2880 270 2900 270 {
lab=ck_gated}
N 2960 120 2980 120 {
lab=VSS}
N 2820 120 2840 120 {
lab=VDD}
N 2780 70 2810 70 {
lab=A3_buf}
N 2780 90 2810 90 {
lab=A4_buf}
N 2990 70 3020 70 {
lab=A3_bar}
N 2990 90 3020 90 {
lab=A4_bar}
N 3290 150 3290 230 {
lab=#net11}
N 3350 180 3350 190 {
lab=VDD}
N 3340 310 3350 310 {
lab=VSS}
N 3270 270 3290 270 {
lab=ck_gated}
N 3350 120 3370 120 {
lab=VSS}
N 3210 120 3230 120 {
lab=VDD}
N 3170 70 3200 70 {
lab=A3_buf}
N 3170 90 3200 90 {
lab=A4_buf}
N 3380 70 3410 70 {
lab=A3_bar}
N 3380 90 3410 90 {
lab=A4_bar}
N 3680 150 3680 230 {
lab=#net12}
N 3740 180 3740 190 {
lab=VDD}
N 3730 310 3740 310 {
lab=VSS}
N 3660 270 3680 270 {
lab=ck_gated}
N 3740 120 3760 120 {
lab=VSS}
N 3600 120 3620 120 {
lab=VDD}
N 3560 70 3590 70 {
lab=A3_buf}
N 3560 90 3590 90 {
lab=A4_buf}
N 3770 70 3800 70 {
lab=A3_bar}
N 3770 90 3800 90 {
lab=A4_bar}
N 4070 150 4070 230 {
lab=#net13}
N 4130 180 4130 190 {
lab=VDD}
N 4120 310 4130 310 {
lab=VSS}
N 4050 270 4070 270 {
lab=ck_gated}
N 4130 120 4150 120 {
lab=VSS}
N 3990 120 4010 120 {
lab=VDD}
N 3950 70 3980 70 {
lab=A3_buf}
N 3950 90 3980 90 {
lab=A4_buf}
N 4160 70 4190 70 {
lab=A3_bar}
N 4160 90 4190 90 {
lab=A4_bar}
N 4460 150 4460 230 {
lab=#net14}
N 4520 180 4520 190 {
lab=VDD}
N 4510 310 4520 310 {
lab=VSS}
N 4440 270 4460 270 {
lab=ck_gated}
N 4520 120 4540 120 {
lab=VSS}
N 4380 120 4400 120 {
lab=VDD}
N 4340 70 4370 70 {
lab=A3_buf}
N 4340 90 4370 90 {
lab=A4_buf}
N 4550 70 4580 70 {
lab=A3_bar}
N 4550 90 4580 90 {
lab=A4_bar}
N 4850 150 4850 230 {
lab=#net15}
N 4910 180 4910 190 {
lab=VDD}
N 4900 310 4910 310 {
lab=VSS}
N 4830 270 4850 270 {
lab=ck_gated}
N 4910 120 4930 120 {
lab=VSS}
N 4770 120 4790 120 {
lab=VDD}
N 4730 70 4760 70 {
lab=A3_buf}
N 4730 90 4760 90 {
lab=A4_buf}
N 4940 70 4970 70 {
lab=A3_bar}
N 4940 90 4970 90 {
lab=A4_bar}
N 5240 150 5240 230 {
lab=#net16}
N 5300 180 5300 190 {
lab=VDD}
N 5290 310 5300 310 {
lab=VSS}
N 5220 270 5240 270 {
lab=ck_gated}
N 5300 120 5320 120 {
lab=VSS}
N 5160 120 5180 120 {
lab=VDD}
N 5120 70 5150 70 {
lab=A3_buf}
N 5120 90 5150 90 {
lab=A4_buf}
N 5330 70 5360 70 {
lab=A3_bar}
N 5330 90 5360 90 {
lab=A4_bar}
N 5630 150 5630 230 {
lab=#net17}
N 5690 180 5690 190 {
lab=VDD}
N 5680 310 5690 310 {
lab=VSS}
N 5610 270 5630 270 {
lab=ck_gated}
N 5690 120 5710 120 {
lab=VSS}
N 5550 120 5570 120 {
lab=VDD}
N 5510 70 5540 70 {
lab=A3_buf}
N 5510 90 5540 90 {
lab=A4_buf}
N 5720 70 5750 70 {
lab=A3_bar}
N 5720 90 5750 90 {
lab=A4_bar}
N 6020 150 6020 230 {
lab=#net18}
N 6080 180 6080 190 {
lab=VDD}
N 6070 310 6080 310 {
lab=VSS}
N 6000 270 6020 270 {
lab=ck_gated}
N 6080 120 6100 120 {
lab=VSS}
N 5940 120 5960 120 {
lab=VDD}
N 5900 70 5930 70 {
lab=A3_buf}
N 5900 90 5930 90 {
lab=A4_buf}
N 6110 70 6140 70 {
lab=A3_bar}
N 6110 90 6140 90 {
lab=A4_bar}
N 6410 150 6410 230 {
lab=#net19}
N 6470 180 6470 190 {
lab=VDD}
N 6460 310 6470 310 {
lab=VSS}
N 6390 270 6410 270 {
lab=ck_gated}
N 6470 120 6490 120 {
lab=VSS}
N 6330 120 6350 120 {
lab=VDD}
N 6290 70 6320 70 {
lab=A3_buf}
N 6290 90 6320 90 {
lab=A4_buf}
N 6500 70 6530 70 {
lab=A3_bar}
N 6500 90 6530 90 {
lab=A4_bar}
N 6800 150 6800 230 {
lab=#net20}
N 6860 180 6860 190 {
lab=VDD}
N 6850 310 6860 310 {
lab=VSS}
N 6780 270 6800 270 {
lab=ck_gated}
N 6860 120 6880 120 {
lab=VSS}
N 6720 120 6740 120 {
lab=VDD}
N 6680 70 6710 70 {
lab=A3_buf}
N 6680 90 6710 90 {
lab=A4_buf}
N 6890 70 6920 70 {
lab=A3_bar}
N 6890 90 6920 90 {
lab=A4_bar}
N 7190 150 7190 230 {
lab=#net21}
N 7250 180 7250 190 {
lab=VDD}
N 7240 310 7250 310 {
lab=VSS}
N 7170 270 7190 270 {
lab=ck_gated}
N 7250 120 7270 120 {
lab=VSS}
N 7110 120 7130 120 {
lab=VDD}
N 7070 70 7100 70 {
lab=A3_buf}
N 7070 90 7100 90 {
lab=A4_buf}
N 7280 70 7310 70 {
lab=A3_bar}
N 7280 90 7310 90 {
lab=A4_bar}
N 7580 150 7580 230 {
lab=#net22}
N 7640 180 7640 190 {
lab=VDD}
N 7630 310 7640 310 {
lab=VSS}
N 7560 270 7580 270 {
lab=ck_gated}
N 7640 120 7660 120 {
lab=VSS}
N 7500 120 7520 120 {
lab=VDD}
N 7460 70 7490 70 {
lab=A3_buf}
N 7460 90 7490 90 {
lab=A4_buf}
N 7670 70 7700 70 {
lab=A3_bar}
N 7670 90 7700 90 {
lab=A4_bar}
N 7970 150 7970 230 {
lab=#net23}
N 8030 180 8030 190 {
lab=VDD}
N 8020 310 8030 310 {
lab=VSS}
N 7950 270 7970 270 {
lab=ck_gated}
N 8030 120 8050 120 {
lab=VSS}
N 7890 120 7910 120 {
lab=VDD}
N 7850 70 7880 70 {
lab=A3_buf}
N 7850 90 7880 90 {
lab=A4_buf}
N 8060 70 8090 70 {
lab=A3_bar}
N 8060 90 8090 90 {
lab=A4_bar}
N 8360 150 8360 230 {
lab=#net24}
N 8420 180 8420 190 {
lab=VDD}
N 8410 310 8420 310 {
lab=VSS}
N 8340 270 8360 270 {
lab=ck_gated}
N 8420 120 8440 120 {
lab=VSS}
N 8280 120 8300 120 {
lab=VDD}
N 8240 70 8270 70 {
lab=A3_buf}
N 8240 90 8270 90 {
lab=A4_buf}
N 8450 70 8480 70 {
lab=A3_bar}
N 8450 90 8480 90 {
lab=A4_bar}
N -1750 -850 -1730 -850 {
lab=VDD}
N -1750 -830 -1730 -830 {
lab=VSS}
N -1760 -770 -1730 -770 {
lab=EN}
N -1230 -810 -1210 -810 {
lab=#net25}
N -1310 -850 -1150 -850 {
lab=VDD}
N -1310 -770 -1150 -770 {
lab=VSS}
N -1070 -810 -1050 -810 {
lab=ram1}
N -1380 -810 -1370 -810 {
lab=Y0}
N -870 -810 -850 -810 {
lab=#net26}
N -950 -850 -790 -850 {
lab=VDD}
N -950 -770 -790 -770 {
lab=VSS}
N -710 -810 -690 -810 {
lab=ram2}
N -1020 -810 -1010 -810 {
lab=Y1}
N -490 -810 -470 -810 {
lab=#net27}
N -570 -850 -410 -850 {
lab=VDD}
N -570 -770 -410 -770 {
lab=VSS}
N -330 -810 -310 -810 {
lab=ram3}
N -640 -810 -630 -810 {
lab=Y2}
N -130 -810 -110 -810 {
lab=#net28}
N -210 -850 -50 -850 {
lab=VDD}
N -210 -770 -50 -770 {
lab=VSS}
N 30 -810 50 -810 {
lab=ram4}
N -280 -810 -270 -810 {
lab=Y3}
N -1570 -840 -1550 -840 {
lab=Y0}
N -1570 -820 -1520 -820 {
lab=Y1}
N -1550 -840 -1520 -840 {
lab=Y0}
N -1570 -800 -1520 -800 {
lab=Y2}
N -1570 -780 -1520 -780 {
lab=Y3}
N -1210 -460 -1210 -440 {
lab=VDD}
N -1210 -280 -1210 -260 {
lab=VSS}
N -1550 -350 -1500 -350 {
lab=CLK_buf}
N -1360 -350 -1290 -350 {
lab=#net29}
N -1290 -320 -1290 -250 {
lab=CLK_buf}
N -1530 -250 -1290 -250 {
lab=CLK_buf}
N -1530 -350 -1530 -250 {
lab=CLK_buf}
N -1290 -250 -1290 -190 {
lab=CLK_buf}
N -1290 -190 -1090 -190 {
lab=CLK_buf}
N -1090 -360 -1090 -190 {
lab=CLK_buf}
N -1130 -400 -1090 -400 {
lab=#net30}
N -950 -380 -930 -380 {
lab=#net31}
N -790 -380 -770 -380 {
lab=#net32}
N -630 -380 -610 -380 {
lab=#net33}
N -2010 -350 -1990 -350 {
lab=#net34}
N -2090 -390 -1930 -390 {
lab=VDD}
N -2090 -310 -1930 -310 {
lab=VSS}
N -1850 -350 -1830 -350 {
lab=CLK_buf}
N -2160 -350 -2150 -350 {
lab=CLK}
N -1360 -1180 -1340 -1180 {
lab=#net35}
N -1440 -1220 -1280 -1220 {
lab=VDD}
N -1440 -1140 -1280 -1140 {
lab=VSS}
N -1200 -1180 -1180 -1180 {
lab=we0_buf}
N -1510 -1180 -1500 -1180 {
lab=WE0}
N -940 -1180 -920 -1180 {
lab=#net36}
N -1020 -1220 -860 -1220 {
lab=VDD}
N -1020 -1140 -860 -1140 {
lab=VSS}
N -780 -1180 -760 -1180 {
lab=we1_buf}
N -1090 -1180 -1080 -1180 {
lab=WE1}
N -490 -1180 -470 -1180 {
lab=#net37}
N -570 -1220 -410 -1220 {
lab=VDD}
N -570 -1140 -410 -1140 {
lab=VSS}
N -330 -1180 -310 -1180 {
lab=we2_buf}
N -640 -1180 -630 -1180 {
lab=WE2}
N -50 -1180 -30 -1180 {
lab=#net38}
N -130 -1220 30 -1220 {
lab=VDD}
N -130 -1140 30 -1140 {
lab=VSS}
N 110 -1180 130 -1180 {
lab=we3_buf}
N -200 -1180 -190 -1180 {
lab=WE3}
N 2200 -2420 2220 -2420 {
lab=#net39}
N 2120 -2460 2280 -2460 {
lab=VDD}
N 2120 -2380 2280 -2380 {
lab=VSS}
N 2360 -2420 2380 -2420 {
lab=di0_buf}
N 2030 -2420 2040 -2420 {
lab=Di0}
N 2760 -2420 2780 -2420 {
lab=di1_buf}
N 2200 -2290 2220 -2290 {
lab=#net40}
N 2120 -2330 2280 -2330 {
lab=VDD}
N 2120 -2250 2280 -2250 {
lab=VSS}
N 2360 -2290 2380 -2290 {
lab=di4_buf}
N 2030 -2290 2040 -2290 {
lab=Di4}
N 3560 -2420 3580 -2420 {
lab=di3_buf}
N 3560 -2290 3580 -2290 {
lab=di7_buf}
N 3160 -2290 3180 -2290 {
lab=di6_buf}
N 3160 -2420 3180 -2420 {
lab=di2_buf}
N 3560 -2420 3580 -2420 {
lab=di3_buf}
N 3560 -2290 3580 -2290 {
lab=di7_buf}
N 2760 -2290 2780 -2290 {
lab=di5_buf}
N 2200 -2160 2220 -2160 {
lab=#net41}
N 2120 -2200 2280 -2200 {
lab=VDD}
N 2120 -2120 2280 -2120 {
lab=VSS}
N 2360 -2160 2380 -2160 {
lab=di8_buf}
N 2030 -2160 2040 -2160 {
lab=Di8}
N 2760 -2160 2780 -2160 {
lab=di9_buf}
N 3160 -2160 3180 -2160 {
lab=di10_buf}
N 3560 -2160 3580 -2160 {
lab=di11_buf}
N 3560 -2030 3580 -2030 {
lab=di15_buf}
N 3160 -2030 3180 -2030 {
lab=di14_buf}
N 2760 -2030 2780 -2030 {
lab=di13_buf}
N 2200 -2030 2220 -2030 {
lab=#net42}
N 2120 -2070 2280 -2070 {
lab=VDD}
N 2120 -1990 2280 -1990 {
lab=VSS}
N 2360 -2030 2380 -2030 {
lab=di12_buf}
N 2030 -2030 2040 -2030 {
lab=Di12}
N 2200 -1900 2220 -1900 {
lab=#net43}
N 2120 -1940 2280 -1940 {
lab=VDD}
N 2120 -1860 2280 -1860 {
lab=VSS}
N 2360 -1900 2380 -1900 {
lab=di16_buf}
N 2030 -1900 2040 -1900 {
lab=Di16}
N 2200 -1770 2220 -1770 {
lab=#net44}
N 2120 -1810 2280 -1810 {
lab=VDD}
N 2120 -1730 2280 -1730 {
lab=VSS}
N 2360 -1770 2380 -1770 {
lab=di20_buf}
N 2030 -1770 2040 -1770 {
lab=Di20}
N 2200 -1640 2220 -1640 {
lab=#net45}
N 2120 -1680 2280 -1680 {
lab=VDD}
N 2120 -1600 2280 -1600 {
lab=VSS}
N 2360 -1640 2380 -1640 {
lab=di24_buf}
N 2030 -1640 2040 -1640 {
lab=Di24}
N 2200 -1510 2220 -1510 {
lab=#net46}
N 2120 -1550 2280 -1550 {
lab=VDD}
N 2120 -1470 2280 -1470 {
lab=VSS}
N 2360 -1510 2380 -1510 {
lab=di28_buf}
N 2030 -1510 2040 -1510 {
lab=Di28}
N 2760 -1510 2780 -1510 {
lab=di29_buf}
N 2760 -1640 2780 -1640 {
lab=di25_buf}
N 2760 -1770 2780 -1770 {
lab=di21_buf}
N 2760 -1900 2780 -1900 {
lab=di17_buf}
N 3160 -1900 3180 -1900 {
lab=di18_buf}
N 3160 -1770 3180 -1770 {
lab=di22_buf}
N 3160 -1640 3180 -1640 {
lab=di26_buf}
N 3160 -1510 3180 -1510 {
lab=di30_buf}
N 3560 -1510 3580 -1510 {
lab=di31_buf}
N 3560 -1640 3580 -1640 {
lab=di27_buf}
N 3560 -1770 3580 -1770 {
lab=di23_buf}
N 3560 -1900 3580 -1900 {
lab=di19_buf}
N 2040 -1510 2060 -1510 {
lab=Di28}
N 2040 -1640 2060 -1640 {
lab=Di24}
N 2040 -1770 2060 -1770 {
lab=Di20}
N 2040 -1900 2060 -1900 {
lab=Di16}
N 2040 -2030 2060 -2030 {
lab=Di12}
N 2040 -2160 2060 -2160 {
lab=Di8}
N 2040 -2290 2060 -2290 {
lab=Di4}
N 2040 -2420 2060 -2420 {
lab=Di0}
N 2600 -2420 2620 -2420 {
lab=#net47}
N 2520 -2460 2680 -2460 {
lab=VDD}
N 2520 -2380 2680 -2380 {
lab=VSS}
N 2600 -2290 2620 -2290 {
lab=#net48}
N 2520 -2330 2680 -2330 {
lab=VDD}
N 2520 -2250 2680 -2250 {
lab=VSS}
N 2600 -2160 2620 -2160 {
lab=#net49}
N 2520 -2200 2680 -2200 {
lab=VDD}
N 2520 -2120 2680 -2120 {
lab=VSS}
N 2600 -2030 2620 -2030 {
lab=#net50}
N 2520 -2070 2680 -2070 {
lab=VDD}
N 2520 -1990 2680 -1990 {
lab=VSS}
N 2600 -1900 2620 -1900 {
lab=#net51}
N 2520 -1940 2680 -1940 {
lab=VDD}
N 2520 -1860 2680 -1860 {
lab=VSS}
N 2600 -1770 2620 -1770 {
lab=#net52}
N 2520 -1810 2680 -1810 {
lab=VDD}
N 2520 -1730 2680 -1730 {
lab=VSS}
N 2600 -1640 2620 -1640 {
lab=#net53}
N 2520 -1680 2680 -1680 {
lab=VDD}
N 2520 -1600 2680 -1600 {
lab=VSS}
N 2600 -1510 2620 -1510 {
lab=#net54}
N 2520 -1550 2680 -1550 {
lab=VDD}
N 2520 -1470 2680 -1470 {
lab=VSS}
N 3000 -2420 3020 -2420 {
lab=#net55}
N 2920 -2460 3080 -2460 {
lab=VDD}
N 2920 -2380 3080 -2380 {
lab=VSS}
N 3000 -2290 3020 -2290 {
lab=#net56}
N 2920 -2330 3080 -2330 {
lab=VDD}
N 2920 -2250 3080 -2250 {
lab=VSS}
N 3000 -2160 3020 -2160 {
lab=#net57}
N 2920 -2200 3080 -2200 {
lab=VDD}
N 2920 -2120 3080 -2120 {
lab=VSS}
N 3000 -2030 3020 -2030 {
lab=#net58}
N 2920 -2070 3080 -2070 {
lab=VDD}
N 2920 -1990 3080 -1990 {
lab=VSS}
N 3000 -1900 3020 -1900 {
lab=#net59}
N 2920 -1940 3080 -1940 {
lab=VDD}
N 2920 -1860 3080 -1860 {
lab=VSS}
N 3000 -1770 3020 -1770 {
lab=#net60}
N 2920 -1810 3080 -1810 {
lab=VDD}
N 2920 -1730 3080 -1730 {
lab=VSS}
N 3000 -1640 3020 -1640 {
lab=#net61}
N 2920 -1680 3080 -1680 {
lab=VDD}
N 2920 -1600 3080 -1600 {
lab=VSS}
N 3000 -1510 3020 -1510 {
lab=#net62}
N 2920 -1550 3080 -1550 {
lab=VDD}
N 2920 -1470 3080 -1470 {
lab=VSS}
N 3400 -2420 3420 -2420 {
lab=#net63}
N 3320 -2460 3480 -2460 {
lab=VDD}
N 3320 -2380 3480 -2380 {
lab=VSS}
N 3400 -2290 3420 -2290 {
lab=#net64}
N 3320 -2330 3480 -2330 {
lab=VDD}
N 3320 -2250 3480 -2250 {
lab=VSS}
N 3400 -2160 3420 -2160 {
lab=#net65}
N 3320 -2200 3480 -2200 {
lab=VDD}
N 3320 -2120 3480 -2120 {
lab=VSS}
N 3400 -2030 3420 -2030 {
lab=#net66}
N 3320 -2070 3480 -2070 {
lab=VDD}
N 3320 -1990 3480 -1990 {
lab=VSS}
N 3400 -1900 3420 -1900 {
lab=#net67}
N 3320 -1940 3480 -1940 {
lab=VDD}
N 3320 -1860 3480 -1860 {
lab=VSS}
N 3400 -1770 3420 -1770 {
lab=#net68}
N 3320 -1810 3480 -1810 {
lab=VDD}
N 3320 -1730 3480 -1730 {
lab=VSS}
N 3400 -1640 3420 -1640 {
lab=#net69}
N 3320 -1680 3480 -1680 {
lab=VDD}
N 3320 -1600 3480 -1600 {
lab=VSS}
N 3400 -1510 3420 -1510 {
lab=#net70}
N 3320 -1550 3480 -1550 {
lab=VDD}
N 3320 -1470 3480 -1470 {
lab=VSS}
N 2840 -2420 2860 -2420 {
lab=Di2}
N 2840 -2290 2860 -2290 {
lab=Di6}
N 2840 -2160 2860 -2160 {
lab=Di10}
N 2840 -2030 2860 -2030 {
lab=Di14}
N 2840 -1900 2860 -1900 {
lab=Di18}
N 2840 -1770 2860 -1770 {
lab=Di22}
N 2840 -1640 2860 -1640 {
lab=Di26}
N 2840 -1510 2860 -1510 {
lab=Di30}
N 3240 -2420 3260 -2420 {
lab=Di3}
N 3240 -2290 3260 -2290 {
lab=Di7}
N 3240 -2160 3260 -2160 {
lab=Di11}
N 3240 -2030 3260 -2030 {
lab=Di15}
N 3240 -1900 3260 -1900 {
lab=Di19}
N 3240 -1770 3260 -1770 {
lab=Di23}
N 3240 -1640 3260 -1640 {
lab=Di27}
N 3240 -1510 3260 -1510 {
lab=Di31}
N 2440 -2420 2460 -2420 {
lab=Di1}
N 2440 -2290 2460 -2290 {
lab=Di5}
N 2440 -2160 2460 -2160 {
lab=Di9}
N 2440 -2030 2460 -2030 {
lab=Di13}
N 2440 -1900 2460 -1900 {
lab=Di17}
N 2440 -1770 2460 -1770 {
lab=Di21}
N 2440 -1640 2460 -1640 {
lab=Di25}
N 2440 -1510 2460 -1510 {
lab=Di29}
N -1470 -1630 -1450 -1630 {
lab=#net71}
N -1550 -1670 -1390 -1670 {
lab=VDD}
N -1550 -1590 -1390 -1590 {
lab=VSS}
N -1310 -1630 -1290 -1630 {
lab=#net72}
N -1620 -1630 -1610 -1630 {
lab=A3}
N -1470 -1480 -1450 -1480 {
lab=#net73}
N -1550 -1520 -1390 -1520 {
lab=VDD}
N -1550 -1440 -1390 -1440 {
lab=VSS}
N -1310 -1480 -1290 -1480 {
lab=#net74}
N -1620 -1480 -1610 -1480 {
lab=A4}
N -1140 -1630 -1120 -1630 {
lab=A3_bar}
N -1220 -1670 -1060 -1670 {
lab=VDD}
N -1220 -1590 -1060 -1590 {
lab=VSS}
N -980 -1630 -960 -1630 {
lab=A3_buf}
N -1290 -1630 -1280 -1630 {
lab=#net72}
N -1140 -1480 -1120 -1480 {
lab=A4_bar}
N -1220 -1520 -1060 -1520 {
lab=VDD}
N -1220 -1440 -1060 -1440 {
lab=VSS}
N -980 -1480 -960 -1480 {
lab=A4_buf}
N -1290 -1480 -1280 -1480 {
lab=#net74}
N -1120 -1720 -1120 -1630 {
lab=A3_bar}
N -1120 -1480 -1120 -1400 {
lab=A4_bar}
N -1480 -1980 -1460 -1980 {
lab=#net75}
N -1560 -2020 -1400 -2020 {
lab=VDD}
N -1560 -1940 -1400 -1940 {
lab=VSS}
N -1320 -1980 -1300 -1980 {
lab=A1_buf}
N -1630 -1980 -1620 -1980 {
lab=A1}
N -1480 -1830 -1460 -1830 {
lab=#net76}
N -1560 -1870 -1400 -1870 {
lab=VDD}
N -1560 -1790 -1400 -1790 {
lab=VSS}
N -1320 -1830 -1300 -1830 {
lab=A2_buf}
N -1630 -1830 -1620 -1830 {
lab=A2}
N -1490 -2140 -1470 -2140 {
lab=#net77}
N -1570 -2180 -1410 -2180 {
lab=VDD}
N -1570 -2100 -1410 -2100 {
lab=VSS}
N -1330 -2140 -1310 -2140 {
lab=A0_buf}
N -1640 -2140 -1630 -2140 {
lab=A0}
N -470 -380 -450 -380 {
lab=ck_gated}
N 170 -380 190 -380 {
lab=#net78}
N 90 -420 250 -420 {
lab=VDD}
N 90 -340 250 -340 {
lab=VSS}
N 330 -380 350 -380 {
lab=RE_buf}
N 20 -380 30 -380 {
lab=RE}
N 1000 -1260 1000 -1240 {
lab=RE_buf}
N 1530 -1260 1530 -1240 {
lab=RE_buf}
N 2070 -1260 2070 -1240 {
lab=RE_buf}
N 2590 -1260 2590 -1240 {
lab=RE_buf}
N -1320 -400 -1290 -400 {
lab=RE_buf}
C {lab_wire.sym} 770 -1170 0 0 {name=l1 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 770 -1150 0 0 {name=l2 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 770 -1130 0 0 {name=l3 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 770 -1110 0 0 {name=l4 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 770 -1090 0 0 {name=l5 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 770 -1070 0 0 {name=l6 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 770 -1050 0 0 {name=l7 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 770 -1030 0 0 {name=l8 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 770 -1010 0 0 {name=l9 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 770 -990 0 0 {name=l10 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 770 -970 0 0 {name=l11 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 770 -950 0 0 {name=l12 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 770 -930 0 0 {name=l13 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 770 -910 0 0 {name=l14 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 770 -890 0 0 {name=l15 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 770 -870 0 0 {name=l16 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 770 -850 0 0 {name=l17 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 770 -830 0 0 {name=l18 sig_type=std_logic lab=di17_buf}
C {lab_wire.sym} 770 -810 0 0 {name=l19 sig_type=std_logic lab=di18_buf}
C {lab_wire.sym} 770 -790 0 0 {name=l20 sig_type=std_logic lab=di19_buf}
C {lab_wire.sym} 770 -770 0 0 {name=l21 sig_type=std_logic lab=di20_buf}
C {lab_wire.sym} 770 -750 0 0 {name=l22 sig_type=std_logic lab=di21_buf}
C {lab_wire.sym} 770 -730 0 0 {name=l23 sig_type=std_logic lab=di22_buf}
C {lab_wire.sym} 770 -710 0 0 {name=l24 sig_type=std_logic lab=di23_buf}
C {lab_wire.sym} 770 -690 0 0 {name=l25 sig_type=std_logic lab=di24_buf}
C {lab_wire.sym} 770 -670 0 0 {name=l26 sig_type=std_logic lab=di25_buf}
C {lab_wire.sym} 770 -650 0 0 {name=l27 sig_type=std_logic lab=di26_buf}
C {lab_wire.sym} 770 -630 0 0 {name=l28 sig_type=std_logic lab=di27_buf}
C {lab_wire.sym} 770 -610 0 0 {name=l29 sig_type=std_logic lab=di28_buf}
C {lab_wire.sym} 770 -590 0 0 {name=l30 sig_type=std_logic lab=di29_buf}
C {lab_wire.sym} 770 -550 0 0 {name=l31 sig_type=std_logic lab=di31_buf}
C {lab_wire.sym} 770 -570 0 0 {name=l32 sig_type=std_logic lab=di30_buf}
C {lab_wire.sym} 820 -1260 0 0 {name=l65 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 920 -1260 1 0 {name=l66 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 940 -1260 1 0 {name=l67 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 960 -1260 1 0 {name=l68 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 980 -1260 1 0 {name=l69 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 1020 -1260 1 0 {name=l70 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1040 -1260 1 0 {name=l71 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 840 -1260 1 0 {name=l34 sig_type=std_logic lab=ram1}
C {lab_wire.sym} 1300 -1170 0 0 {name=l37 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 1300 -1150 0 0 {name=l38 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 1300 -1130 0 0 {name=l39 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 1300 -1110 0 0 {name=l40 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 1300 -1090 0 0 {name=l41 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 1300 -1070 0 0 {name=l42 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 1300 -1050 0 0 {name=l43 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 1300 -1030 0 0 {name=l44 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 1300 -1010 0 0 {name=l45 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 1300 -990 0 0 {name=l46 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 1300 -970 0 0 {name=l47 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 1300 -950 0 0 {name=l48 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 1300 -930 0 0 {name=l49 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 1300 -910 0 0 {name=l50 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 1300 -890 0 0 {name=l51 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 1300 -870 0 0 {name=l52 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 1300 -850 0 0 {name=l53 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 1300 -830 0 0 {name=l54 sig_type=std_logic lab=di17_buf}
C {lab_wire.sym} 1300 -810 0 0 {name=l55 sig_type=std_logic lab=di18_buf}
C {lab_wire.sym} 1300 -790 0 0 {name=l56 sig_type=std_logic lab=di19_buf}
C {lab_wire.sym} 1300 -770 0 0 {name=l57 sig_type=std_logic lab=di20_buf}
C {lab_wire.sym} 1300 -750 0 0 {name=l58 sig_type=std_logic lab=di21_buf}
C {lab_wire.sym} 1300 -730 0 0 {name=l59 sig_type=std_logic lab=di22_buf}
C {lab_wire.sym} 1300 -710 0 0 {name=l60 sig_type=std_logic lab=di23_buf}
C {lab_wire.sym} 1300 -690 0 0 {name=l61 sig_type=std_logic lab=di24_buf}
C {lab_wire.sym} 1300 -670 0 0 {name=l62 sig_type=std_logic lab=di25_buf}
C {lab_wire.sym} 1300 -650 0 0 {name=l63 sig_type=std_logic lab=di26_buf}
C {lab_wire.sym} 1300 -630 0 0 {name=l64 sig_type=std_logic lab=di27_buf}
C {lab_wire.sym} 1300 -610 0 0 {name=l72 sig_type=std_logic lab=di28_buf}
C {lab_wire.sym} 1300 -590 0 0 {name=l73 sig_type=std_logic lab=di29_buf}
C {lab_wire.sym} 1300 -550 0 0 {name=l74 sig_type=std_logic lab=di31_buf}
C {lab_wire.sym} 1300 -570 0 0 {name=l75 sig_type=std_logic lab=di30_buf}
C {lab_wire.sym} 1350 -1260 0 0 {name=l76 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 1470 -1260 1 0 {name=l78 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 1490 -1260 1 0 {name=l79 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 1510 -1260 1 0 {name=l80 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 1550 -1260 1 0 {name=l81 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1570 -1260 1 0 {name=l82 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1370 -1260 1 0 {name=l86 sig_type=std_logic lab=ram2}
C {lab_wire.sym} 1840 -1170 0 0 {name=l87 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 1840 -1150 0 0 {name=l88 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 1840 -1130 0 0 {name=l89 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 1840 -1110 0 0 {name=l90 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 1840 -1090 0 0 {name=l91 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 1840 -1070 0 0 {name=l92 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 1840 -1050 0 0 {name=l93 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 1840 -1030 0 0 {name=l94 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 1840 -1010 0 0 {name=l95 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 1840 -990 0 0 {name=l96 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 1840 -970 0 0 {name=l97 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 1840 -950 0 0 {name=l98 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 1840 -930 0 0 {name=l99 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 1840 -910 0 0 {name=l100 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 1840 -890 0 0 {name=l101 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 1840 -870 0 0 {name=l102 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 1840 -850 0 0 {name=l103 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 1840 -830 0 0 {name=l104 sig_type=std_logic lab=di17_buf}
C {lab_wire.sym} 1840 -810 0 0 {name=l105 sig_type=std_logic lab=di18_buf}
C {lab_wire.sym} 1840 -790 0 0 {name=l106 sig_type=std_logic lab=di19_buf}
C {lab_wire.sym} 1840 -770 0 0 {name=l107 sig_type=std_logic lab=di20_buf}
C {lab_wire.sym} 1840 -750 0 0 {name=l108 sig_type=std_logic lab=di21_buf}
C {lab_wire.sym} 1840 -730 0 0 {name=l109 sig_type=std_logic lab=di22_buf}
C {lab_wire.sym} 1840 -710 0 0 {name=l110 sig_type=std_logic lab=di23_buf}
C {lab_wire.sym} 1840 -690 0 0 {name=l111 sig_type=std_logic lab=di24_buf}
C {lab_wire.sym} 1840 -670 0 0 {name=l112 sig_type=std_logic lab=di25_buf}
C {lab_wire.sym} 1840 -650 0 0 {name=l113 sig_type=std_logic lab=di26_buf}
C {lab_wire.sym} 1840 -630 0 0 {name=l114 sig_type=std_logic lab=di27_buf}
C {lab_wire.sym} 1840 -610 0 0 {name=l115 sig_type=std_logic lab=di28_buf}
C {lab_wire.sym} 1840 -590 0 0 {name=l116 sig_type=std_logic lab=di29_buf}
C {lab_wire.sym} 1840 -550 0 0 {name=l117 sig_type=std_logic lab=di31_buf}
C {lab_wire.sym} 1840 -570 0 0 {name=l118 sig_type=std_logic lab=di30_buf}
C {lab_wire.sym} 1890 -1260 0 0 {name=l119 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 1990 -1260 1 0 {name=l120 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 2010 -1260 1 0 {name=l121 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 2030 -1260 1 0 {name=l122 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 2050 -1260 1 0 {name=l123 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 2090 -1260 1 0 {name=l124 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2110 -1260 1 0 {name=l125 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1910 -1260 1 0 {name=l129 sig_type=std_logic lab=ram3}
C {lab_wire.sym} 2360 -1170 0 0 {name=l130 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 2360 -1150 0 0 {name=l131 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 2360 -1130 0 0 {name=l132 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 2360 -1110 0 0 {name=l133 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 2360 -1090 0 0 {name=l134 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 2360 -1070 0 0 {name=l135 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 2360 -1050 0 0 {name=l136 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 2360 -1030 0 0 {name=l137 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 2360 -1010 0 0 {name=l138 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 2360 -990 0 0 {name=l139 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 2360 -970 0 0 {name=l140 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 2360 -950 0 0 {name=l141 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 2360 -930 0 0 {name=l142 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 2360 -910 0 0 {name=l143 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 2360 -890 0 0 {name=l144 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 2360 -870 0 0 {name=l145 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 2360 -850 0 0 {name=l146 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 2360 -830 0 0 {name=l147 sig_type=std_logic lab=di17_buf}
C {lab_wire.sym} 2360 -810 0 0 {name=l148 sig_type=std_logic lab=di18_buf}
C {lab_wire.sym} 2360 -790 0 0 {name=l149 sig_type=std_logic lab=di19_buf}
C {lab_wire.sym} 2360 -770 0 0 {name=l150 sig_type=std_logic lab=di20_buf}
C {lab_wire.sym} 2360 -750 0 0 {name=l151 sig_type=std_logic lab=di21_buf}
C {lab_wire.sym} 2360 -730 0 0 {name=l152 sig_type=std_logic lab=di22_buf}
C {lab_wire.sym} 2360 -710 0 0 {name=l153 sig_type=std_logic lab=di23_buf}
C {lab_wire.sym} 2360 -690 0 0 {name=l154 sig_type=std_logic lab=di24_buf}
C {lab_wire.sym} 2360 -670 0 0 {name=l155 sig_type=std_logic lab=di25_buf}
C {lab_wire.sym} 2360 -650 0 0 {name=l156 sig_type=std_logic lab=di26_buf}
C {lab_wire.sym} 2360 -630 0 0 {name=l157 sig_type=std_logic lab=di27_buf}
C {lab_wire.sym} 2360 -610 0 0 {name=l158 sig_type=std_logic lab=di28_buf}
C {lab_wire.sym} 2360 -590 0 0 {name=l159 sig_type=std_logic lab=di29_buf}
C {lab_wire.sym} 2360 -550 0 0 {name=l160 sig_type=std_logic lab=di31_buf}
C {lab_wire.sym} 2360 -570 0 0 {name=l161 sig_type=std_logic lab=di30_buf}
C {lab_wire.sym} 2410 -1260 0 0 {name=l162 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} 2510 -1260 1 0 {name=l163 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 2530 -1260 1 0 {name=l164 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} 2550 -1260 1 0 {name=l165 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} 2570 -1260 1 0 {name=l166 sig_type=std_logic lab=we3_buf}
C {lab_wire.sym} 2610 -1260 1 0 {name=l167 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2630 -1260 1 0 {name=l168 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2430 -1260 1 0 {name=l172 sig_type=std_logic lab=ram4}
C {xschem_lib/DFFRAM_full_custom/RAM8.sym} 940 -850 0 0 {name=xram1 NF=2}
C {xschem_lib/DFFRAM_full_custom/RAM8.sym} 1470 -850 0 0 {name=xram2 NF=2}
C {xschem_lib/DFFRAM_full_custom/RAM8.sym} 2010 -850 0 0 {name=xram3 NF=2}
C {xschem_lib/DFFRAM_full_custom/RAM8.sym} 2530 -850 0 0 {name=xram4 NF=2}
C {lab_wire.sym} 1450 -1260 1 0 {name=l77 sig_type=std_logic lab=we0_buf}
C {lab_wire.sym} 860 -1260 1 0 {name=l83 sig_type=std_logic lab=A0_buf}
C {lab_wire.sym} 900 -1260 1 0 {name=l84 sig_type=std_logic lab=A2_buf}
C {lab_wire.sym} 880 -1260 1 0 {name=l85 sig_type=std_logic lab=A1_buf}
C {lab_wire.sym} 1390 -1260 1 0 {name=l126 sig_type=std_logic lab=A0_buf}
C {lab_wire.sym} 1430 -1260 1 0 {name=l127 sig_type=std_logic lab=A2_buf}
C {lab_wire.sym} 1410 -1260 1 0 {name=l128 sig_type=std_logic lab=A1_buf}
C {lab_wire.sym} 1930 -1260 1 0 {name=l169 sig_type=std_logic lab=A0_buf}
C {lab_wire.sym} 1970 -1260 1 0 {name=l170 sig_type=std_logic lab=A2_buf}
C {lab_wire.sym} 1950 -1260 1 0 {name=l171 sig_type=std_logic lab=A1_buf}
C {lab_wire.sym} 2450 -1260 1 0 {name=l173 sig_type=std_logic lab=A0_buf}
C {lab_wire.sym} 2490 -1260 1 0 {name=l174 sig_type=std_logic lab=A2_buf}
C {lab_wire.sym} 2470 -1260 1 0 {name=l175 sig_type=std_logic lab=A1_buf}
C {lab_wire.sym} 1110 -1170 2 0 {name=l33 sig_type=std_logic lab=ram1_do0}
C {lab_wire.sym} 1110 -1150 2 0 {name=l35 sig_type=std_logic lab=ram1_do1}
C {lab_wire.sym} 1110 -1130 2 0 {name=l36 sig_type=std_logic lab=ram1_do2}
C {lab_wire.sym} 1110 -1110 2 0 {name=l176 sig_type=std_logic lab=ram1_do3}
C {lab_wire.sym} 1110 -1090 2 0 {name=l177 sig_type=std_logic lab=ram1_do4}
C {lab_wire.sym} 1110 -1070 2 0 {name=l178 sig_type=std_logic lab=ram1_do5}
C {lab_wire.sym} 1110 -1050 2 0 {name=l179 sig_type=std_logic lab=ram1_do6}
C {lab_wire.sym} 1110 -1030 2 0 {name=l180 sig_type=std_logic lab=ram1_do7}
C {lab_wire.sym} 1110 -1010 2 0 {name=l181 sig_type=std_logic lab=ram1_do8}
C {lab_wire.sym} 1110 -990 2 0 {name=l182 sig_type=std_logic lab=ram1_do9}
C {lab_wire.sym} 1110 -970 2 0 {name=l183 sig_type=std_logic lab=ram1_do10}
C {lab_wire.sym} 1110 -950 2 0 {name=l184 sig_type=std_logic lab=ram1_do11}
C {lab_wire.sym} 1110 -930 2 0 {name=l185 sig_type=std_logic lab=ram1_do12}
C {lab_wire.sym} 1110 -910 2 0 {name=l186 sig_type=std_logic lab=ram1_do13}
C {lab_wire.sym} 1110 -890 2 0 {name=l187 sig_type=std_logic lab=ram1_do14}
C {lab_wire.sym} 1110 -870 2 0 {name=l188 sig_type=std_logic lab=ram1_do15}
C {lab_wire.sym} 1110 -850 2 0 {name=l189 sig_type=std_logic lab=ram1_do16}
C {lab_wire.sym} 1110 -830 2 0 {name=l190 sig_type=std_logic lab=ram1_do17}
C {lab_wire.sym} 1110 -810 2 0 {name=l191 sig_type=std_logic lab=ram1_do18}
C {lab_wire.sym} 1110 -790 2 0 {name=l192 sig_type=std_logic lab=ram1_do19}
C {lab_wire.sym} 1110 -770 2 0 {name=l193 sig_type=std_logic lab=ram1_do20}
C {lab_wire.sym} 1110 -750 2 0 {name=l194 sig_type=std_logic lab=ram1_do21}
C {lab_wire.sym} 1110 -730 2 0 {name=l195 sig_type=std_logic lab=ram1_do22}
C {lab_wire.sym} 1110 -710 2 0 {name=l196 sig_type=std_logic lab=ram1_do23}
C {lab_wire.sym} 1110 -690 2 0 {name=l197 sig_type=std_logic lab=ram1_do24}
C {lab_wire.sym} 1110 -670 2 0 {name=l198 sig_type=std_logic lab=ram1_do25}
C {lab_wire.sym} 1110 -650 2 0 {name=l199 sig_type=std_logic lab=ram1_do26}
C {lab_wire.sym} 1110 -630 2 0 {name=l200 sig_type=std_logic lab=ram1_do27}
C {lab_wire.sym} 1110 -610 2 0 {name=l201 sig_type=std_logic lab=ram1_do28}
C {lab_wire.sym} 1110 -590 2 0 {name=l202 sig_type=std_logic lab=ram1_do29}
C {lab_wire.sym} 1110 -570 2 0 {name=l203 sig_type=std_logic lab=ram1_do30}
C {lab_wire.sym} 1110 -550 2 0 {name=l204 sig_type=std_logic lab=ram1_do31}
C {lab_wire.sym} 1640 -1170 2 0 {name=l205 sig_type=std_logic lab=ram2_do0}
C {lab_wire.sym} 1640 -1150 2 0 {name=l206 sig_type=std_logic lab=ram2_do1}
C {lab_wire.sym} 1640 -1130 2 0 {name=l207 sig_type=std_logic lab=ram2_do2}
C {lab_wire.sym} 1640 -1110 2 0 {name=l208 sig_type=std_logic lab=ram2_do3}
C {lab_wire.sym} 1640 -1090 2 0 {name=l209 sig_type=std_logic lab=ram2_do4}
C {lab_wire.sym} 1640 -1070 2 0 {name=l210 sig_type=std_logic lab=ram2_do5}
C {lab_wire.sym} 1640 -1050 2 0 {name=l211 sig_type=std_logic lab=ram2_do6}
C {lab_wire.sym} 1640 -1030 2 0 {name=l212 sig_type=std_logic lab=ram2_do7}
C {lab_wire.sym} 1640 -1010 2 0 {name=l213 sig_type=std_logic lab=ram2_do8}
C {lab_wire.sym} 1640 -990 2 0 {name=l214 sig_type=std_logic lab=ram2_do9}
C {lab_wire.sym} 1640 -970 2 0 {name=l215 sig_type=std_logic lab=ram2_do10}
C {lab_wire.sym} 1640 -950 2 0 {name=l216 sig_type=std_logic lab=ram2_do11}
C {lab_wire.sym} 1640 -930 2 0 {name=l217 sig_type=std_logic lab=ram2_do12}
C {lab_wire.sym} 1640 -910 2 0 {name=l218 sig_type=std_logic lab=ram2_do13}
C {lab_wire.sym} 1640 -890 2 0 {name=l219 sig_type=std_logic lab=ram2_do14}
C {lab_wire.sym} 1640 -870 2 0 {name=l220 sig_type=std_logic lab=ram2_do15}
C {lab_wire.sym} 1640 -850 2 0 {name=l221 sig_type=std_logic lab=ram2_do16}
C {lab_wire.sym} 1640 -830 2 0 {name=l222 sig_type=std_logic lab=ram2_do17}
C {lab_wire.sym} 1640 -810 2 0 {name=l223 sig_type=std_logic lab=ram2_do18}
C {lab_wire.sym} 1640 -790 2 0 {name=l224 sig_type=std_logic lab=ram2_do19}
C {lab_wire.sym} 1640 -770 2 0 {name=l225 sig_type=std_logic lab=ram2_do20}
C {lab_wire.sym} 1640 -750 2 0 {name=l226 sig_type=std_logic lab=ram2_do21}
C {lab_wire.sym} 1640 -730 2 0 {name=l227 sig_type=std_logic lab=ram2_do22}
C {lab_wire.sym} 1640 -710 2 0 {name=l228 sig_type=std_logic lab=ram2_do23}
C {lab_wire.sym} 1640 -690 2 0 {name=l229 sig_type=std_logic lab=ram2_do24}
C {lab_wire.sym} 1640 -670 2 0 {name=l230 sig_type=std_logic lab=ram2_do25}
C {lab_wire.sym} 1640 -650 2 0 {name=l231 sig_type=std_logic lab=ram2_do26}
C {lab_wire.sym} 1640 -630 2 0 {name=l232 sig_type=std_logic lab=ram2_do27}
C {lab_wire.sym} 1640 -610 2 0 {name=l233 sig_type=std_logic lab=ram2_do28}
C {lab_wire.sym} 1640 -590 2 0 {name=l234 sig_type=std_logic lab=ram2_do29}
C {lab_wire.sym} 1640 -570 2 0 {name=l235 sig_type=std_logic lab=ram2_do30}
C {lab_wire.sym} 1640 -550 2 0 {name=l236 sig_type=std_logic lab=ram2_do31}
C {lab_wire.sym} 2180 -1170 2 0 {name=l237 sig_type=std_logic lab=ram3_do0}
C {lab_wire.sym} 2180 -1150 2 0 {name=l238 sig_type=std_logic lab=ram3_do1}
C {lab_wire.sym} 2180 -1130 2 0 {name=l239 sig_type=std_logic lab=ram3_do2}
C {lab_wire.sym} 2180 -1110 2 0 {name=l240 sig_type=std_logic lab=ram3_do3}
C {lab_wire.sym} 2180 -1090 2 0 {name=l241 sig_type=std_logic lab=ram3_do4}
C {lab_wire.sym} 2180 -1070 2 0 {name=l242 sig_type=std_logic lab=ram3_do5}
C {lab_wire.sym} 2180 -1050 2 0 {name=l243 sig_type=std_logic lab=ram3_do6}
C {lab_wire.sym} 2180 -1030 2 0 {name=l244 sig_type=std_logic lab=ram3_do7}
C {lab_wire.sym} 2180 -1010 2 0 {name=l245 sig_type=std_logic lab=ram3_do8}
C {lab_wire.sym} 2180 -990 2 0 {name=l246 sig_type=std_logic lab=ram3_do9}
C {lab_wire.sym} 2180 -970 2 0 {name=l247 sig_type=std_logic lab=ram3_do10}
C {lab_wire.sym} 2180 -950 2 0 {name=l248 sig_type=std_logic lab=ram3_do11}
C {lab_wire.sym} 2180 -930 2 0 {name=l249 sig_type=std_logic lab=ram3_do12}
C {lab_wire.sym} 2180 -910 2 0 {name=l250 sig_type=std_logic lab=ram3_do13}
C {lab_wire.sym} 2180 -890 2 0 {name=l251 sig_type=std_logic lab=ram3_do14}
C {lab_wire.sym} 2180 -870 2 0 {name=l252 sig_type=std_logic lab=ram3_do15}
C {lab_wire.sym} 2180 -850 2 0 {name=l253 sig_type=std_logic lab=ram3_do16}
C {lab_wire.sym} 2180 -830 2 0 {name=l254 sig_type=std_logic lab=ram3_do17}
C {lab_wire.sym} 2180 -810 2 0 {name=l255 sig_type=std_logic lab=ram3_do18}
C {lab_wire.sym} 2180 -790 2 0 {name=l256 sig_type=std_logic lab=ram3_do19}
C {lab_wire.sym} 2180 -770 2 0 {name=l257 sig_type=std_logic lab=ram3_do20}
C {lab_wire.sym} 2180 -750 2 0 {name=l258 sig_type=std_logic lab=ram3_do21}
C {lab_wire.sym} 2180 -730 2 0 {name=l259 sig_type=std_logic lab=ram3_do22}
C {lab_wire.sym} 2180 -710 2 0 {name=l260 sig_type=std_logic lab=ram3_do23}
C {lab_wire.sym} 2180 -690 2 0 {name=l261 sig_type=std_logic lab=ram3_do24}
C {lab_wire.sym} 2180 -670 2 0 {name=l262 sig_type=std_logic lab=ram3_do25}
C {lab_wire.sym} 2180 -650 2 0 {name=l263 sig_type=std_logic lab=ram3_do26}
C {lab_wire.sym} 2180 -630 2 0 {name=l264 sig_type=std_logic lab=ram3_do27}
C {lab_wire.sym} 2180 -610 2 0 {name=l265 sig_type=std_logic lab=ram3_do28}
C {lab_wire.sym} 2180 -590 2 0 {name=l266 sig_type=std_logic lab=ram3_do29}
C {lab_wire.sym} 2180 -570 2 0 {name=l267 sig_type=std_logic lab=ram3_do30}
C {lab_wire.sym} 2180 -550 2 0 {name=l268 sig_type=std_logic lab=ram3_do31}
C {lab_wire.sym} 2700 -1170 2 0 {name=l269 sig_type=std_logic lab=ram4_do0}
C {lab_wire.sym} 2700 -1150 2 0 {name=l270 sig_type=std_logic lab=ram4_do1}
C {lab_wire.sym} 2700 -1130 2 0 {name=l271 sig_type=std_logic lab=ram4_do2}
C {lab_wire.sym} 2700 -1110 2 0 {name=l272 sig_type=std_logic lab=ram4_do3}
C {lab_wire.sym} 2700 -1090 2 0 {name=l273 sig_type=std_logic lab=ram4_do4}
C {lab_wire.sym} 2700 -1070 2 0 {name=l274 sig_type=std_logic lab=ram4_do5}
C {lab_wire.sym} 2700 -1050 2 0 {name=l275 sig_type=std_logic lab=ram4_do6}
C {lab_wire.sym} 2700 -1030 2 0 {name=l276 sig_type=std_logic lab=ram4_do7}
C {lab_wire.sym} 2700 -1010 2 0 {name=l277 sig_type=std_logic lab=ram4_do8}
C {lab_wire.sym} 2700 -990 2 0 {name=l278 sig_type=std_logic lab=ram4_do9}
C {lab_wire.sym} 2700 -970 2 0 {name=l279 sig_type=std_logic lab=ram4_do10}
C {lab_wire.sym} 2700 -950 2 0 {name=l280 sig_type=std_logic lab=ram4_do11}
C {lab_wire.sym} 2700 -930 2 0 {name=l281 sig_type=std_logic lab=ram4_do12}
C {lab_wire.sym} 2700 -910 2 0 {name=l282 sig_type=std_logic lab=ram4_do13}
C {lab_wire.sym} 2700 -890 2 0 {name=l283 sig_type=std_logic lab=ram4_do14}
C {lab_wire.sym} 2700 -870 2 0 {name=l284 sig_type=std_logic lab=ram4_do15}
C {lab_wire.sym} 2700 -850 2 0 {name=l285 sig_type=std_logic lab=ram4_do16}
C {lab_wire.sym} 2700 -830 2 0 {name=l286 sig_type=std_logic lab=ram4_do17}
C {lab_wire.sym} 2700 -810 2 0 {name=l287 sig_type=std_logic lab=ram4_do18}
C {lab_wire.sym} 2700 -790 2 0 {name=l288 sig_type=std_logic lab=ram4_do19}
C {lab_wire.sym} 2700 -770 2 0 {name=l289 sig_type=std_logic lab=ram4_do20}
C {lab_wire.sym} 2700 -750 2 0 {name=l290 sig_type=std_logic lab=ram4_do21}
C {lab_wire.sym} 2700 -730 2 0 {name=l291 sig_type=std_logic lab=ram4_do22}
C {lab_wire.sym} 2700 -710 2 0 {name=l292 sig_type=std_logic lab=ram4_do23}
C {lab_wire.sym} 2700 -690 2 0 {name=l293 sig_type=std_logic lab=ram4_do24}
C {lab_wire.sym} 2700 -670 2 0 {name=l294 sig_type=std_logic lab=ram4_do25}
C {lab_wire.sym} 2700 -650 2 0 {name=l295 sig_type=std_logic lab=ram4_do26}
C {lab_wire.sym} 2700 -630 2 0 {name=l296 sig_type=std_logic lab=ram4_do27}
C {lab_wire.sym} 2700 -610 2 0 {name=l297 sig_type=std_logic lab=ram4_do28}
C {lab_wire.sym} 2700 -590 2 0 {name=l298 sig_type=std_logic lab=ram4_do29}
C {lab_wire.sym} 2700 -570 2 0 {name=l299 sig_type=std_logic lab=ram4_do30}
C {lab_wire.sym} 2700 -550 2 0 {name=l300 sig_type=std_logic lab=ram4_do31}
C {xschem_lib/DFFRAM_full_custom/dec_2to4.sym} -1650 -810 0 0 {name=x1 NF=2}
C {lab_wire.sym} -3760 0 1 0 {name=l329 sig_type=std_logic lab=ram1_do0}
C {lab_wire.sym} -3740 0 1 0 {name=l330 sig_type=std_logic lab=ram2_do0}
C {lab_wire.sym} -3720 0 1 0 {name=l331 sig_type=std_logic lab=ram3_do0}
C {lab_wire.sym} -3700 0 1 0 {name=l332 sig_type=std_logic lab=ram4_do0}
C {lab_wire.sym} -3600 360 0 0 {name=l333 sig_type=std_logic lab=do0}
C {lab_wire.sym} -3370 0 1 0 {name=l334 sig_type=std_logic lab=ram1_do1}
C {lab_wire.sym} -3350 0 1 0 {name=l335 sig_type=std_logic lab=ram2_do1}
C {lab_wire.sym} -3330 0 1 0 {name=l336 sig_type=std_logic lab=ram3_do1}
C {lab_wire.sym} -3310 0 1 0 {name=l337 sig_type=std_logic lab=ram4_do1}
C {lab_wire.sym} -3210 360 0 0 {name=l338 sig_type=std_logic lab=do1}
C {lab_wire.sym} -2980 0 1 0 {name=l339 sig_type=std_logic lab=ram1_do2}
C {lab_wire.sym} -2960 0 1 0 {name=l340 sig_type=std_logic lab=ram2_do2}
C {lab_wire.sym} -2940 0 1 0 {name=l341 sig_type=std_logic lab=ram3_do2}
C {lab_wire.sym} -2920 0 1 0 {name=l342 sig_type=std_logic lab=ram4_do2}
C {lab_wire.sym} -2820 360 0 0 {name=l343 sig_type=std_logic lab=do2}
C {lab_wire.sym} -2590 0 1 0 {name=l344 sig_type=std_logic lab=ram1_do3}
C {lab_wire.sym} -2570 0 1 0 {name=l345 sig_type=std_logic lab=ram2_do3}
C {lab_wire.sym} -2550 0 1 0 {name=l346 sig_type=std_logic lab=ram3_do3}
C {lab_wire.sym} -2530 0 1 0 {name=l347 sig_type=std_logic lab=ram4_do3}
C {lab_wire.sym} -2430 360 0 0 {name=l348 sig_type=std_logic lab=do3}
C {lab_wire.sym} -2200 0 1 0 {name=l349 sig_type=std_logic lab=ram1_do4}
C {lab_wire.sym} -2180 0 1 0 {name=l350 sig_type=std_logic lab=ram2_do4}
C {lab_wire.sym} -2160 0 1 0 {name=l351 sig_type=std_logic lab=ram3_do4}
C {lab_wire.sym} -2140 0 1 0 {name=l352 sig_type=std_logic lab=ram4_do4}
C {lab_wire.sym} -2040 360 0 0 {name=l353 sig_type=std_logic lab=do4}
C {lab_wire.sym} -1810 0 1 0 {name=l354 sig_type=std_logic lab=ram1_do5}
C {lab_wire.sym} -1790 0 1 0 {name=l355 sig_type=std_logic lab=ram2_do5}
C {lab_wire.sym} -1770 0 1 0 {name=l356 sig_type=std_logic lab=ram3_do5}
C {lab_wire.sym} -1750 0 1 0 {name=l357 sig_type=std_logic lab=ram4_do5}
C {lab_wire.sym} -1650 360 0 0 {name=l358 sig_type=std_logic lab=do5}
C {lab_wire.sym} -1420 0 1 0 {name=l359 sig_type=std_logic lab=ram1_do6}
C {lab_wire.sym} -1400 0 1 0 {name=l360 sig_type=std_logic lab=ram2_do6}
C {lab_wire.sym} -1380 0 1 0 {name=l361 sig_type=std_logic lab=ram3_do6}
C {lab_wire.sym} -1360 0 1 0 {name=l362 sig_type=std_logic lab=ram4_do6}
C {lab_wire.sym} -1260 360 0 0 {name=l363 sig_type=std_logic lab=do6}
C {lab_wire.sym} -1030 0 1 0 {name=l364 sig_type=std_logic lab=ram1_do7}
C {lab_wire.sym} -1010 0 1 0 {name=l365 sig_type=std_logic lab=ram2_do7}
C {lab_wire.sym} -990 0 1 0 {name=l366 sig_type=std_logic lab=ram3_do7}
C {lab_wire.sym} -970 0 1 0 {name=l367 sig_type=std_logic lab=ram4_do7}
C {lab_wire.sym} -870 360 0 0 {name=l368 sig_type=std_logic lab=do7}
C {lab_wire.sym} -640 0 1 0 {name=l369 sig_type=std_logic lab=ram1_do8}
C {lab_wire.sym} -620 0 1 0 {name=l370 sig_type=std_logic lab=ram2_do8}
C {lab_wire.sym} -600 0 1 0 {name=l371 sig_type=std_logic lab=ram3_do8}
C {lab_wire.sym} -580 0 1 0 {name=l372 sig_type=std_logic lab=ram4_do8}
C {lab_wire.sym} -480 360 0 0 {name=l373 sig_type=std_logic lab=do8}
C {lab_wire.sym} -250 0 1 0 {name=l374 sig_type=std_logic lab=ram1_do9}
C {lab_wire.sym} -230 0 1 0 {name=l375 sig_type=std_logic lab=ram2_do9}
C {lab_wire.sym} -210 0 1 0 {name=l376 sig_type=std_logic lab=ram3_do9}
C {lab_wire.sym} -190 0 1 0 {name=l377 sig_type=std_logic lab=ram4_do9}
C {lab_wire.sym} -90 360 0 0 {name=l378 sig_type=std_logic lab=do9}
C {lab_wire.sym} 140 0 1 0 {name=l379 sig_type=std_logic lab=ram1_do10}
C {lab_wire.sym} 160 0 1 0 {name=l380 sig_type=std_logic lab=ram2_do10}
C {lab_wire.sym} 180 0 1 0 {name=l381 sig_type=std_logic lab=ram3_do10}
C {lab_wire.sym} 200 0 1 0 {name=l382 sig_type=std_logic lab=ram4_do10}
C {lab_wire.sym} 300 360 0 0 {name=l383 sig_type=std_logic lab=do10}
C {lab_wire.sym} 530 0 1 0 {name=l384 sig_type=std_logic lab=ram1_do11}
C {lab_wire.sym} 550 0 1 0 {name=l385 sig_type=std_logic lab=ram2_do11}
C {lab_wire.sym} 570 0 1 0 {name=l386 sig_type=std_logic lab=ram3_do11}
C {lab_wire.sym} 590 0 1 0 {name=l387 sig_type=std_logic lab=ram4_do11}
C {lab_wire.sym} 690 360 0 0 {name=l388 sig_type=std_logic lab=do11}
C {lab_wire.sym} 920 0 1 0 {name=l389 sig_type=std_logic lab=ram1_do12}
C {lab_wire.sym} 940 0 1 0 {name=l390 sig_type=std_logic lab=ram2_do12}
C {lab_wire.sym} 960 0 1 0 {name=l391 sig_type=std_logic lab=ram3_do12}
C {lab_wire.sym} 980 0 1 0 {name=l392 sig_type=std_logic lab=ram4_do12}
C {lab_wire.sym} 1080 360 0 0 {name=l393 sig_type=std_logic lab=do12}
C {lab_wire.sym} 1310 0 1 0 {name=l394 sig_type=std_logic lab=ram1_do13}
C {lab_wire.sym} 1330 0 1 0 {name=l395 sig_type=std_logic lab=ram2_do13}
C {lab_wire.sym} 1350 0 1 0 {name=l396 sig_type=std_logic lab=ram3_do13}
C {lab_wire.sym} 1370 0 1 0 {name=l397 sig_type=std_logic lab=ram4_do13}
C {lab_wire.sym} 1470 360 0 0 {name=l398 sig_type=std_logic lab=do13}
C {lab_wire.sym} 1700 0 1 0 {name=l399 sig_type=std_logic lab=ram1_do14}
C {lab_wire.sym} 1720 0 1 0 {name=l400 sig_type=std_logic lab=ram2_do14}
C {lab_wire.sym} 1740 0 1 0 {name=l401 sig_type=std_logic lab=ram3_do14}
C {lab_wire.sym} 1760 0 1 0 {name=l402 sig_type=std_logic lab=ram4_do14}
C {lab_wire.sym} 1860 360 0 0 {name=l403 sig_type=std_logic lab=do14}
C {lab_wire.sym} 2090 0 1 0 {name=l404 sig_type=std_logic lab=ram1_do15}
C {lab_wire.sym} 2110 0 1 0 {name=l405 sig_type=std_logic lab=ram2_do15}
C {lab_wire.sym} 2130 0 1 0 {name=l406 sig_type=std_logic lab=ram3_do15}
C {lab_wire.sym} 2150 0 1 0 {name=l407 sig_type=std_logic lab=ram4_do15}
C {lab_wire.sym} 2250 360 0 0 {name=l408 sig_type=std_logic lab=do15}
C {lab_wire.sym} 2480 0 1 0 {name=l409 sig_type=std_logic lab=ram1_do16}
C {lab_wire.sym} 2500 0 1 0 {name=l410 sig_type=std_logic lab=ram2_do16}
C {lab_wire.sym} 2520 0 1 0 {name=l411 sig_type=std_logic lab=ram3_do16}
C {lab_wire.sym} 2540 0 1 0 {name=l412 sig_type=std_logic lab=ram4_do16}
C {lab_wire.sym} 2640 360 0 0 {name=l413 sig_type=std_logic lab=do16}
C {lab_wire.sym} 2870 0 1 0 {name=l414 sig_type=std_logic lab=ram1_do17}
C {lab_wire.sym} 2890 0 1 0 {name=l415 sig_type=std_logic lab=ram2_do17}
C {lab_wire.sym} 2910 0 1 0 {name=l416 sig_type=std_logic lab=ram3_do17}
C {lab_wire.sym} 2930 0 1 0 {name=l417 sig_type=std_logic lab=ram4_do17}
C {lab_wire.sym} 3030 360 0 0 {name=l418 sig_type=std_logic lab=do17}
C {lab_wire.sym} 3260 0 1 0 {name=l419 sig_type=std_logic lab=ram1_do18}
C {lab_wire.sym} 3280 0 1 0 {name=l420 sig_type=std_logic lab=ram2_do18}
C {lab_wire.sym} 3300 0 1 0 {name=l421 sig_type=std_logic lab=ram3_do18}
C {lab_wire.sym} 3320 0 1 0 {name=l422 sig_type=std_logic lab=ram4_do18}
C {lab_wire.sym} 3420 360 0 0 {name=l423 sig_type=std_logic lab=do18}
C {lab_wire.sym} 3650 0 1 0 {name=l424 sig_type=std_logic lab=ram1_do19}
C {lab_wire.sym} 3670 0 1 0 {name=l425 sig_type=std_logic lab=ram2_do19}
C {lab_wire.sym} 3690 0 1 0 {name=l426 sig_type=std_logic lab=ram3_do19}
C {lab_wire.sym} 3710 0 1 0 {name=l427 sig_type=std_logic lab=ram4_do19}
C {lab_wire.sym} 3810 360 0 0 {name=l428 sig_type=std_logic lab=do19}
C {lab_wire.sym} 4040 0 1 0 {name=l429 sig_type=std_logic lab=ram1_do20}
C {lab_wire.sym} 4060 0 1 0 {name=l430 sig_type=std_logic lab=ram2_do20}
C {lab_wire.sym} 4080 0 1 0 {name=l431 sig_type=std_logic lab=ram3_do20}
C {lab_wire.sym} 4100 0 1 0 {name=l432 sig_type=std_logic lab=ram4_do20}
C {lab_wire.sym} 4200 360 0 0 {name=l433 sig_type=std_logic lab=do20}
C {lab_wire.sym} 4430 0 1 0 {name=l434 sig_type=std_logic lab=ram1_do21}
C {lab_wire.sym} 4450 0 1 0 {name=l435 sig_type=std_logic lab=ram2_do21}
C {lab_wire.sym} 4470 0 1 0 {name=l436 sig_type=std_logic lab=ram3_do21}
C {lab_wire.sym} 4490 0 1 0 {name=l437 sig_type=std_logic lab=ram4_do21}
C {lab_wire.sym} 4590 360 0 0 {name=l438 sig_type=std_logic lab=do21}
C {lab_wire.sym} 4820 0 1 0 {name=l439 sig_type=std_logic lab=ram1_do22}
C {lab_wire.sym} 4840 0 1 0 {name=l440 sig_type=std_logic lab=ram2_do22}
C {lab_wire.sym} 4860 0 1 0 {name=l441 sig_type=std_logic lab=ram3_do22}
C {lab_wire.sym} 4880 0 1 0 {name=l442 sig_type=std_logic lab=ram4_do22}
C {lab_wire.sym} 4980 360 0 0 {name=l443 sig_type=std_logic lab=do22}
C {lab_wire.sym} 5210 0 1 0 {name=l444 sig_type=std_logic lab=ram1_do23}
C {lab_wire.sym} 5230 0 1 0 {name=l445 sig_type=std_logic lab=ram2_do23}
C {lab_wire.sym} 5250 0 1 0 {name=l446 sig_type=std_logic lab=ram3_do23}
C {lab_wire.sym} 5270 0 1 0 {name=l447 sig_type=std_logic lab=ram4_do23}
C {lab_wire.sym} 5370 360 0 0 {name=l448 sig_type=std_logic lab=do23}
C {lab_wire.sym} 5600 0 1 0 {name=l449 sig_type=std_logic lab=ram1_do24}
C {lab_wire.sym} 5620 0 1 0 {name=l450 sig_type=std_logic lab=ram2_do24}
C {lab_wire.sym} 5640 0 1 0 {name=l451 sig_type=std_logic lab=ram3_do24}
C {lab_wire.sym} 5660 0 1 0 {name=l452 sig_type=std_logic lab=ram4_do24}
C {lab_wire.sym} 5760 360 0 0 {name=l453 sig_type=std_logic lab=do24}
C {lab_wire.sym} 5990 0 1 0 {name=l454 sig_type=std_logic lab=ram1_do25}
C {lab_wire.sym} 6010 0 1 0 {name=l455 sig_type=std_logic lab=ram2_do25}
C {lab_wire.sym} 6030 0 1 0 {name=l456 sig_type=std_logic lab=ram3_do25}
C {lab_wire.sym} 6050 0 1 0 {name=l457 sig_type=std_logic lab=ram4_do25}
C {lab_wire.sym} 6150 360 0 0 {name=l458 sig_type=std_logic lab=do25}
C {lab_wire.sym} 6380 0 1 0 {name=l459 sig_type=std_logic lab=ram1_do26}
C {lab_wire.sym} 6400 0 1 0 {name=l460 sig_type=std_logic lab=ram2_do26}
C {lab_wire.sym} 6420 0 1 0 {name=l461 sig_type=std_logic lab=ram3_do26}
C {lab_wire.sym} 6440 0 1 0 {name=l462 sig_type=std_logic lab=ram4_do26}
C {lab_wire.sym} 6540 360 0 0 {name=l463 sig_type=std_logic lab=do26}
C {lab_wire.sym} 6770 0 1 0 {name=l464 sig_type=std_logic lab=ram1_do27}
C {lab_wire.sym} 6790 0 1 0 {name=l465 sig_type=std_logic lab=ram2_do27}
C {lab_wire.sym} 6810 0 1 0 {name=l466 sig_type=std_logic lab=ram3_do27}
C {lab_wire.sym} 6830 0 1 0 {name=l467 sig_type=std_logic lab=ram4_do27}
C {lab_wire.sym} 6930 360 0 0 {name=l468 sig_type=std_logic lab=do27}
C {lab_wire.sym} 7160 0 1 0 {name=l469 sig_type=std_logic lab=ram1_do28}
C {lab_wire.sym} 7180 0 1 0 {name=l470 sig_type=std_logic lab=ram2_do28}
C {lab_wire.sym} 7200 0 1 0 {name=l471 sig_type=std_logic lab=ram3_do28}
C {lab_wire.sym} 7220 0 1 0 {name=l472 sig_type=std_logic lab=ram4_do28}
C {lab_wire.sym} 7320 360 0 0 {name=l473 sig_type=std_logic lab=do28}
C {lab_wire.sym} 7550 0 1 0 {name=l474 sig_type=std_logic lab=ram1_do29}
C {lab_wire.sym} 7570 0 1 0 {name=l475 sig_type=std_logic lab=ram2_do29}
C {lab_wire.sym} 7590 0 1 0 {name=l476 sig_type=std_logic lab=ram3_do29}
C {lab_wire.sym} 7610 0 1 0 {name=l477 sig_type=std_logic lab=ram4_do29}
C {lab_wire.sym} 7710 360 0 0 {name=l478 sig_type=std_logic lab=do29}
C {lab_wire.sym} 7940 0 1 0 {name=l479 sig_type=std_logic lab=ram1_do30}
C {lab_wire.sym} 7960 0 1 0 {name=l480 sig_type=std_logic lab=ram2_do30}
C {lab_wire.sym} 7980 0 1 0 {name=l481 sig_type=std_logic lab=ram3_do30}
C {lab_wire.sym} 8000 0 1 0 {name=l482 sig_type=std_logic lab=ram4_do30}
C {lab_wire.sym} 8100 360 0 0 {name=l483 sig_type=std_logic lab=do30}
C {lab_wire.sym} 8330 0 1 0 {name=l484 sig_type=std_logic lab=ram1_do31}
C {lab_wire.sym} 8350 0 1 0 {name=l485 sig_type=std_logic lab=ram2_do31}
C {lab_wire.sym} 8370 0 1 0 {name=l486 sig_type=std_logic lab=ram3_do31}
C {lab_wire.sym} 8390 0 1 0 {name=l487 sig_type=std_logic lab=ram4_do31}
C {lab_wire.sym} 8490 360 0 0 {name=l488 sig_type=std_logic lab=do31}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} -3730 90 3 1 {name=xMux3 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} -3670 250 0 0 {name=xDFF4 NF=1}
C {lab_wire.sym} -3810 120 3 0 {name=l489 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -3650 120 3 0 {name=l490 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -3670 180 0 0 {name=l491 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -3680 310 0 0 {name=l492 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -3850 70 0 0 {name=l493 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} -3850 90 0 0 {name=l494 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} -3610 70 2 0 {name=l495 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} -3610 90 2 0 {name=l496 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} -3750 270 0 0 {name=l497 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} -3340 90 3 1 {name=xMux4 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} -3280 250 0 0 {name=xDFF5 NF=1}
C {lab_wire.sym} -3420 120 3 0 {name=l498 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -3260 120 3 0 {name=l499 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -3280 180 0 0 {name=l500 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -3290 310 0 0 {name=l501 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -3460 70 0 0 {name=l502 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} -3460 90 0 0 {name=l503 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} -3220 70 2 0 {name=l504 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} -3220 90 2 0 {name=l505 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} -3360 270 0 0 {name=l506 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} -2950 90 3 1 {name=xMux5 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} -2890 250 0 0 {name=xDFF6 NF=1}
C {lab_wire.sym} -3030 120 3 0 {name=l507 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -2870 120 3 0 {name=l508 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -2890 180 0 0 {name=l509 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -2900 310 0 0 {name=l510 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -3070 70 0 0 {name=l511 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} -3070 90 0 0 {name=l512 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} -2830 70 2 0 {name=l513 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} -2830 90 2 0 {name=l514 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} -2970 270 0 0 {name=l515 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} -2560 90 3 1 {name=xMux6 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} -2500 250 0 0 {name=xDFF7 NF=1}
C {lab_wire.sym} -2640 120 3 0 {name=l516 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -2480 120 3 0 {name=l517 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -2500 180 0 0 {name=l518 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -2510 310 0 0 {name=l519 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -2680 70 0 0 {name=l520 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} -2680 90 0 0 {name=l521 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} -2440 70 2 0 {name=l522 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} -2440 90 2 0 {name=l523 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} -2580 270 0 0 {name=l524 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} -2170 90 3 1 {name=xMux7 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} -2110 250 0 0 {name=xDFF8 NF=1}
C {lab_wire.sym} -2250 120 3 0 {name=l525 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -2090 120 3 0 {name=l526 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -2110 180 0 0 {name=l527 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -2120 310 0 0 {name=l528 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -2290 70 0 0 {name=l529 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} -2290 90 0 0 {name=l530 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} -2050 70 2 0 {name=l531 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} -2050 90 2 0 {name=l532 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} -2190 270 0 0 {name=l533 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} -1780 90 3 1 {name=xMux8 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} -1720 250 0 0 {name=xDFF9 NF=1}
C {lab_wire.sym} -1860 120 3 0 {name=l534 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1700 120 3 0 {name=l535 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1720 180 0 0 {name=l536 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1730 310 0 0 {name=l537 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1900 70 0 0 {name=l538 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} -1900 90 0 0 {name=l539 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} -1660 70 2 0 {name=l540 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} -1660 90 2 0 {name=l541 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} -1800 270 0 0 {name=l542 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} -1390 90 3 1 {name=xMux9 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} -1330 250 0 0 {name=xDFF10 NF=1}
C {lab_wire.sym} -1470 120 3 0 {name=l543 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1310 120 3 0 {name=l544 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1330 180 0 0 {name=l545 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1340 310 0 0 {name=l546 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1510 70 0 0 {name=l547 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} -1510 90 0 0 {name=l548 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} -1270 70 2 0 {name=l549 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} -1270 90 2 0 {name=l550 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} -1410 270 0 0 {name=l551 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} -1000 90 3 1 {name=xMux10 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} -940 250 0 0 {name=xDFF11 NF=1}
C {lab_wire.sym} -1080 120 3 0 {name=l552 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -920 120 3 0 {name=l553 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -940 180 0 0 {name=l554 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -950 310 0 0 {name=l555 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1120 70 0 0 {name=l556 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} -1120 90 0 0 {name=l557 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} -880 70 2 0 {name=l558 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} -880 90 2 0 {name=l559 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} -1020 270 0 0 {name=l560 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} -610 90 3 1 {name=xMux11 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} -550 250 0 0 {name=xDFF12 NF=1}
C {lab_wire.sym} -690 120 3 0 {name=l561 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -530 120 3 0 {name=l562 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -550 180 0 0 {name=l563 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -560 310 0 0 {name=l564 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -730 70 0 0 {name=l565 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} -730 90 0 0 {name=l566 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} -490 70 2 0 {name=l567 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} -490 90 2 0 {name=l568 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} -630 270 0 0 {name=l569 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} -220 90 3 1 {name=xMux12 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} -160 250 0 0 {name=xDFF13 NF=1}
C {lab_wire.sym} -300 120 3 0 {name=l570 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -140 120 3 0 {name=l571 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -160 180 0 0 {name=l572 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -170 310 0 0 {name=l573 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -340 70 0 0 {name=l574 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} -340 90 0 0 {name=l575 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} -100 70 2 0 {name=l576 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} -100 90 2 0 {name=l577 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} -240 270 0 0 {name=l578 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 170 90 3 1 {name=xMux13 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 230 250 0 0 {name=xDFF14 NF=1}
C {lab_wire.sym} 90 120 3 0 {name=l579 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 250 120 3 0 {name=l580 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 230 180 0 0 {name=l581 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 220 310 0 0 {name=l582 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 50 70 0 0 {name=l583 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 50 90 0 0 {name=l584 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 290 70 2 0 {name=l585 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 290 90 2 0 {name=l586 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 150 270 0 0 {name=l587 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 560 90 3 1 {name=xMux14 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 620 250 0 0 {name=xDFF15 NF=1}
C {lab_wire.sym} 480 120 3 0 {name=l588 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 640 120 3 0 {name=l589 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 620 180 0 0 {name=l590 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 610 310 0 0 {name=l591 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 440 70 0 0 {name=l592 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 440 90 0 0 {name=l593 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 680 70 2 0 {name=l594 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 680 90 2 0 {name=l595 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 540 270 0 0 {name=l596 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 950 90 3 1 {name=xMux15 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 1010 250 0 0 {name=xDFF16 NF=1}
C {lab_wire.sym} 870 120 3 0 {name=l597 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1030 120 3 0 {name=l598 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1010 180 0 0 {name=l599 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1000 310 0 0 {name=l600 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 830 70 0 0 {name=l601 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 830 90 0 0 {name=l602 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 1070 70 2 0 {name=l603 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 1070 90 2 0 {name=l604 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 930 270 0 0 {name=l605 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 1340 90 3 1 {name=xMux16 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 1400 250 0 0 {name=xDFF17 NF=1}
C {lab_wire.sym} 1260 120 3 0 {name=l606 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1420 120 3 0 {name=l607 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1400 180 0 0 {name=l608 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1390 310 0 0 {name=l609 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1220 70 0 0 {name=l610 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 1220 90 0 0 {name=l611 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 1460 70 2 0 {name=l612 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 1460 90 2 0 {name=l613 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 1320 270 0 0 {name=l614 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 1730 90 3 1 {name=xMux17 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 1790 250 0 0 {name=xDFF18 NF=1}
C {lab_wire.sym} 1650 120 3 0 {name=l615 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1810 120 3 0 {name=l616 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1790 180 0 0 {name=l617 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1780 310 0 0 {name=l618 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 1610 70 0 0 {name=l619 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 1610 90 0 0 {name=l620 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 1850 70 2 0 {name=l621 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 1850 90 2 0 {name=l622 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 1710 270 0 0 {name=l623 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 2120 90 3 1 {name=xMux18 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 2180 250 0 0 {name=xDFF19 NF=1}
C {lab_wire.sym} 2040 120 3 0 {name=l624 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2200 120 3 0 {name=l625 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2180 180 0 0 {name=l626 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2170 310 0 0 {name=l627 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2000 70 0 0 {name=l628 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 2000 90 0 0 {name=l629 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 2240 70 2 0 {name=l630 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 2240 90 2 0 {name=l631 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 2100 270 0 0 {name=l632 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 2510 90 3 1 {name=xMux19 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 2570 250 0 0 {name=xDFF20 NF=1}
C {lab_wire.sym} 2430 120 3 0 {name=l633 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2590 120 3 0 {name=l634 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2570 180 0 0 {name=l635 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2560 310 0 0 {name=l636 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2390 70 0 0 {name=l637 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 2390 90 0 0 {name=l638 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 2630 70 2 0 {name=l639 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 2630 90 2 0 {name=l640 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 2490 270 0 0 {name=l641 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 2900 90 3 1 {name=xMux20 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 2960 250 0 0 {name=xDFF21 NF=1}
C {lab_wire.sym} 2820 120 3 0 {name=l642 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2980 120 3 0 {name=l643 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2960 180 0 0 {name=l644 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2950 310 0 0 {name=l645 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2780 70 0 0 {name=l646 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 2780 90 0 0 {name=l647 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 3020 70 2 0 {name=l648 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 3020 90 2 0 {name=l649 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 2880 270 0 0 {name=l650 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 3290 90 3 1 {name=xMux21 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 3350 250 0 0 {name=xDFF22 NF=1}
C {lab_wire.sym} 3210 120 3 0 {name=l651 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3370 120 3 0 {name=l652 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3350 180 0 0 {name=l653 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3340 310 0 0 {name=l654 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3170 70 0 0 {name=l655 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 3170 90 0 0 {name=l656 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 3410 70 2 0 {name=l657 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 3410 90 2 0 {name=l658 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 3270 270 0 0 {name=l659 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 3680 90 3 1 {name=xMux22 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 3740 250 0 0 {name=xDFF23 NF=1}
C {lab_wire.sym} 3600 120 3 0 {name=l660 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3760 120 3 0 {name=l661 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3740 180 0 0 {name=l662 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3730 310 0 0 {name=l663 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3560 70 0 0 {name=l664 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 3560 90 0 0 {name=l665 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 3800 70 2 0 {name=l666 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 3800 90 2 0 {name=l667 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 3660 270 0 0 {name=l668 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 4070 90 3 1 {name=xMux23 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 4130 250 0 0 {name=xDFF24 NF=1}
C {lab_wire.sym} 3990 120 3 0 {name=l669 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4150 120 3 0 {name=l670 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4130 180 0 0 {name=l671 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4120 310 0 0 {name=l672 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3950 70 0 0 {name=l673 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 3950 90 0 0 {name=l674 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 4190 70 2 0 {name=l675 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 4190 90 2 0 {name=l676 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 4050 270 0 0 {name=l677 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 4460 90 3 1 {name=xMux24 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 4520 250 0 0 {name=xDFF25 NF=1}
C {lab_wire.sym} 4380 120 3 0 {name=l678 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4540 120 3 0 {name=l679 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4520 180 0 0 {name=l680 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4510 310 0 0 {name=l681 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4340 70 0 0 {name=l682 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 4340 90 0 0 {name=l683 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 4580 70 2 0 {name=l684 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 4580 90 2 0 {name=l685 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 4440 270 0 0 {name=l686 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 4850 90 3 1 {name=xMux25 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 4910 250 0 0 {name=xDFF26 NF=1}
C {lab_wire.sym} 4770 120 3 0 {name=l687 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4930 120 3 0 {name=l688 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4910 180 0 0 {name=l689 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4900 310 0 0 {name=l690 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 4730 70 0 0 {name=l691 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 4730 90 0 0 {name=l692 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 4970 70 2 0 {name=l693 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 4970 90 2 0 {name=l694 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 4830 270 0 0 {name=l695 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 5240 90 3 1 {name=xMux26 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 5300 250 0 0 {name=xDFF27 NF=1}
C {lab_wire.sym} 5160 120 3 0 {name=l696 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5320 120 3 0 {name=l697 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 5300 180 0 0 {name=l698 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5290 310 0 0 {name=l699 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 5120 70 0 0 {name=l700 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 5120 90 0 0 {name=l701 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 5360 70 2 0 {name=l702 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 5360 90 2 0 {name=l703 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 5220 270 0 0 {name=l704 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 5630 90 3 1 {name=xMux27 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 5690 250 0 0 {name=xDFF28 NF=1}
C {lab_wire.sym} 5550 120 3 0 {name=l705 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5710 120 3 0 {name=l706 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 5690 180 0 0 {name=l707 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5680 310 0 0 {name=l708 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 5510 70 0 0 {name=l709 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 5510 90 0 0 {name=l710 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 5750 70 2 0 {name=l711 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 5750 90 2 0 {name=l712 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 5610 270 0 0 {name=l713 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 6020 90 3 1 {name=xMux28 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 6080 250 0 0 {name=xDFF29 NF=1}
C {lab_wire.sym} 5940 120 3 0 {name=l714 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 6100 120 3 0 {name=l715 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 6080 180 0 0 {name=l716 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 6070 310 0 0 {name=l717 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 5900 70 0 0 {name=l718 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 5900 90 0 0 {name=l719 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 6140 70 2 0 {name=l720 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 6140 90 2 0 {name=l721 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 6000 270 0 0 {name=l722 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 6410 90 3 1 {name=xMux29 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 6470 250 0 0 {name=xDFF30 NF=1}
C {lab_wire.sym} 6330 120 3 0 {name=l723 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 6490 120 3 0 {name=l724 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 6470 180 0 0 {name=l725 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 6460 310 0 0 {name=l726 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 6290 70 0 0 {name=l727 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 6290 90 0 0 {name=l728 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 6530 70 2 0 {name=l729 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 6530 90 2 0 {name=l730 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 6390 270 0 0 {name=l731 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 6800 90 3 1 {name=xMux30 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 6860 250 0 0 {name=xDFF31 NF=1}
C {lab_wire.sym} 6720 120 3 0 {name=l732 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 6880 120 3 0 {name=l733 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 6860 180 0 0 {name=l734 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 6850 310 0 0 {name=l735 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 6680 70 0 0 {name=l736 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 6680 90 0 0 {name=l737 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 6920 70 2 0 {name=l738 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 6920 90 2 0 {name=l739 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 6780 270 0 0 {name=l740 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 7190 90 3 1 {name=xMux31 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 7250 250 0 0 {name=xDFF32 NF=1}
C {lab_wire.sym} 7110 120 3 0 {name=l741 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 7270 120 3 0 {name=l742 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 7250 180 0 0 {name=l743 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 7240 310 0 0 {name=l744 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 7070 70 0 0 {name=l745 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 7070 90 0 0 {name=l746 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 7310 70 2 0 {name=l747 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 7310 90 2 0 {name=l748 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 7170 270 0 0 {name=l749 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 7580 90 3 1 {name=xMux32 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 7640 250 0 0 {name=xDFF33 NF=1}
C {lab_wire.sym} 7500 120 3 0 {name=l750 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 7660 120 3 0 {name=l751 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 7640 180 0 0 {name=l752 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 7630 310 0 0 {name=l753 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 7460 70 0 0 {name=l754 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 7460 90 0 0 {name=l755 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 7700 70 2 0 {name=l756 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 7700 90 2 0 {name=l757 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 7560 270 0 0 {name=l758 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 7970 90 3 1 {name=xMux33 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 8030 250 0 0 {name=xDFF34 NF=1}
C {lab_wire.sym} 7890 120 3 0 {name=l759 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 8050 120 3 0 {name=l760 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 8030 180 0 0 {name=l761 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 8020 310 0 0 {name=l762 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 7850 70 0 0 {name=l763 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 7850 90 0 0 {name=l764 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 8090 70 2 0 {name=l765 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 8090 90 2 0 {name=l766 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 7950 270 0 0 {name=l767 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/mux4to1.sym} 8360 90 3 1 {name=xMux34 NF=2}
C {xschem_lib/DFFRAM_full_custom/DFF.sym} 8420 250 0 0 {name=xDFF35 NF=1}
C {lab_wire.sym} 8280 120 3 0 {name=l768 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 8440 120 3 0 {name=l769 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 8420 180 0 0 {name=l770 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 8410 310 0 0 {name=l771 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 8240 70 0 0 {name=l772 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} 8240 90 0 0 {name=l773 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} 8480 70 2 0 {name=l774 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} 8480 90 2 0 {name=l775 sig_type=std_logic lab=A4_bar}
C {lab_wire.sym} 8340 270 0 0 {name=l776 sig_type=std_logic lab=ck_gated}
C {lab_pin.sym} -1750 -850 0 0 {name=l301 sig_type=std_logic lab=VDD}
C {lab_pin.sym} -1750 -830 0 0 {name=l302 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -1760 -810 0 0 {name=l303 sig_type=std_logic lab=A3}
C {lab_pin.sym} -1760 -790 0 0 {name=l304 sig_type=std_logic lab=A4}
C {lab_pin.sym} -1760 -770 0 0 {name=l305 sig_type=std_logic lab=EN}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1370 -770 0 0 {name=X_inv1 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1210 -770 0 0 {name=X_inv2 NF=8}
C {lab_wire.sym} -1230 -850 0 0 {name=l2283 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1230 -770 0 0 {name=l2284 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1380 -810 0 0 {name=l2317 sig_type=std_logic lab=Y0}
C {lab_wire.sym} -1050 -810 0 0 {name=l2318 sig_type=std_logic lab=ram1}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1010 -770 0 0 {name=X_inv3 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -850 -770 0 0 {name=X_inv4 NF=8}
C {lab_wire.sym} -870 -850 0 0 {name=l2319 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -870 -770 0 0 {name=l2320 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1020 -810 0 0 {name=l2321 sig_type=std_logic lab=Y1}
C {lab_wire.sym} -690 -810 0 0 {name=l2322 sig_type=std_logic lab=ram2}
C {lab_wire.sym} -490 -850 0 0 {name=l2323 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -490 -770 0 0 {name=l2324 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -640 -810 0 0 {name=l2325 sig_type=std_logic lab=Y2}
C {lab_wire.sym} -310 -810 0 0 {name=l2326 sig_type=std_logic lab=ram3}
C {lab_wire.sym} -130 -850 0 0 {name=l2327 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -130 -770 0 0 {name=l2328 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -280 -810 0 0 {name=l2329 sig_type=std_logic lab=Y3}
C {lab_wire.sym} 50 -810 0 0 {name=l2330 sig_type=std_logic lab=ram4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -630 -770 0 0 {name=X_inv5 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -470 -770 0 0 {name=X_inv6 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -270 -770 0 0 {name=X_inv7 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -110 -770 0 0 {name=X_inv8 NF=8}
C {lab_wire.sym} -1520 -840 0 0 {name=l306 sig_type=std_logic lab=Y0}
C {lab_wire.sym} -1520 -820 0 0 {name=l307 sig_type=std_logic lab=Y1}
C {lab_wire.sym} -1520 -800 0 0 {name=l308 sig_type=std_logic lab=Y2}
C {lab_wire.sym} -1520 -780 0 0 {name=l309 sig_type=std_logic lab=Y3}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1500 -310 0 0 {name=X_inv9 NF=1}
C {xschem_lib/DFFRAM_full_custom/latch.sym} -1290 -280 0 0 {name=X_latch1 NF=2}
C {lab_wire.sym} -1440 -390 2 0 {name=l310 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1440 -310 2 0 {name=l311 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/nand.sym} -1070 -350 0 0 {name=X_nand1 NF=2}
C {lab_wire.sym} -1040 -430 1 0 {name=l312 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1040 -330 2 0 {name=l313 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -930 -340 0 0 {name=X_inv10 NF=4}
C {lab_wire.sym} -870 -420 1 0 {name=l314 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -870 -340 2 0 {name=l315 sig_type=std_logic lab=VSS}
C {lab_pin.sym} -1550 -350 0 0 {name=l316 sig_type=std_logic lab=CLK_buf}
C {lab_wire.sym} -1210 -460 1 0 {name=l317 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1210 -260 2 0 {name=l318 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -450 -380 2 0 {name=l319 sig_type=std_logic lab=ck_gated}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -770 -340 0 0 {name=X_inv11 NF=12}
C {lab_wire.sym} -710 -420 1 0 {name=l320 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -710 -340 2 0 {name=l321 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -2150 -310 0 0 {name=X_inv12 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1990 -310 0 0 {name=X_inv13 NF=16}
C {lab_wire.sym} -2010 -390 0 0 {name=l322 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -2010 -310 0 0 {name=l323 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -2160 -350 0 0 {name=l324 sig_type=std_logic lab=CLK}
C {lab_wire.sym} -1830 -350 2 0 {name=l325 sig_type=std_logic lab=CLK_buf}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1500 -1140 0 0 {name=X_inv14 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1340 -1140 0 0 {name=X_inv15 NF=8}
C {lab_wire.sym} -1360 -1220 0 0 {name=l326 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1360 -1140 0 0 {name=l327 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1510 -1180 0 0 {name=l328 sig_type=std_logic lab=WE0}
C {lab_wire.sym} -1180 -1180 2 0 {name=l777 sig_type=std_logic lab=we0_buf}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1080 -1140 0 0 {name=X_inv16 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -920 -1140 0 0 {name=X_inv17 NF=8}
C {lab_wire.sym} -940 -1220 0 0 {name=l778 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -940 -1140 0 0 {name=l779 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1090 -1180 0 0 {name=l780 sig_type=std_logic lab=WE1}
C {lab_wire.sym} -760 -1180 2 0 {name=l781 sig_type=std_logic lab=we1_buf}
C {lab_wire.sym} -490 -1220 0 0 {name=l782 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -490 -1140 0 0 {name=l783 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -640 -1180 0 0 {name=l784 sig_type=std_logic lab=WE2}
C {lab_wire.sym} -310 -1180 2 0 {name=l785 sig_type=std_logic lab=we2_buf}
C {lab_wire.sym} -50 -1220 0 0 {name=l786 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -50 -1140 0 0 {name=l787 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -200 -1180 0 0 {name=l788 sig_type=std_logic lab=WE3}
C {lab_wire.sym} 130 -1180 2 0 {name=l789 sig_type=std_logic lab=we3_buf}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -630 -1140 0 0 {name=X_inv18 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -470 -1140 0 0 {name=X_inv19 NF=8}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -190 -1140 0 0 {name=X_inv20 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -30 -1140 0 0 {name=X_inv21 NF=8}
C {gnd.sym} 20 -1850 0 0 {name=l2649 lab=GND}
C {lab_pin.sym} 20 -1910 0 0 {name=l2650 sig_type=std_logic lab=CLK}
C {vsource.sym} 20 -1760 0 0 {name=V2 value=3.3}
C {gnd.sym} 20 -1730 0 0 {name=l2651 lab=GND}
C {lab_pin.sym} 20 -1790 0 0 {name=l2652 sig_type=std_logic lab=VDD}
C {vsource.sym} 100 -1760 0 0 {name=V3 value=0}
C {gnd.sym} 100 -1730 0 0 {name=l2653 lab=GND}
C {lab_pin.sym} 100 -1790 0 0 {name=l2654 sig_type=std_logic lab=VSS}
C {gnd.sym} 270 -1650 0 0 {name=l2655 lab=GND}
C {lab_pin.sym} 270 -1710 0 0 {name=l2656 sig_type=std_logic lab=A2}
C {gnd.sym} 270 -1830 0 0 {name=l2657 lab=GND}
C {lab_pin.sym} 270 -1890 0 0 {name=l2658 sig_type=std_logic lab=A0}
C {gnd.sym} 270 -1740 0 0 {name=l2659 lab=GND}
C {lab_pin.sym} 270 -1800 0 0 {name=l2660 sig_type=std_logic lab=A1}
C {gnd.sym} 500 -1740 0 0 {name=l2661 lab=GND}
C {lab_pin.sym} 500 -1800 0 0 {name=l2662 sig_type=std_logic lab=A4}
C {gnd.sym} 500 -1830 0 0 {name=l2663 lab=GND}
C {lab_pin.sym} 500 -1890 0 0 {name=l2664 sig_type=std_logic lab=A3}
C {gnd.sym} 500 -1650 0 0 {name=l2665 lab=GND}
C {lab_pin.sym} 500 -1710 0 0 {name=l2666 sig_type=std_logic lab=EN}
C {gnd.sym} 260 -1980 0 0 {name=l2667 lab=GND}
C {lab_pin.sym} 260 -2040 0 0 {name=l2668 sig_type=std_logic lab=Di3}
C {gnd.sym} 260 -2250 0 0 {name=l2669 lab=GND}
C {lab_pin.sym} 260 -2310 0 0 {name=l2670 sig_type=std_logic lab=Di0}
C {gnd.sym} 260 -2070 0 0 {name=l2671 lab=GND}
C {lab_pin.sym} 260 -2130 0 0 {name=l2672 sig_type=std_logic lab=Di2}
C {gnd.sym} 490 -2160 0 0 {name=l2673 lab=GND}
C {lab_pin.sym} 490 -2220 0 0 {name=l2674 sig_type=std_logic lab=Di5}
C {gnd.sym} 490 -2250 0 0 {name=l2675 lab=GND}
C {lab_pin.sym} 490 -2310 0 0 {name=l2676 sig_type=std_logic lab=Di4}
C {gnd.sym} 490 -2070 0 0 {name=l2679 lab=GND}
C {lab_pin.sym} 490 -2130 0 0 {name=l2680 sig_type=std_logic lab=Di6}
C {gnd.sym} 490 -1980 0 0 {name=l2681 lab=GND}
C {lab_pin.sym} 490 -2040 0 0 {name=l2682 sig_type=std_logic lab=Di7}
C {gnd.sym} 260 -2160 0 0 {name=l2677 lab=GND}
C {lab_pin.sym} 260 -2220 0 0 {name=l2678 sig_type=std_logic lab=Di1}
C {vsource.sym} 20 -1880 0 0 {name=V18 value="PULSE(0V 3.3 2n 50p 50p 2n 4n)"}
C {vsource.sym} 260 -2280 0 0 {name=V10 value="PULSE(0V 3.3 8n 50p 50p 12n 24n)"}
C {vsource.sym} 270 -1860 0 0 {name=V4 value="PULSE(0V 3.3 4n 50p 50p 36n 72n)"}
C {vsource.sym} 270 -1770 0 0 {name=V5 value=0}
C {vsource.sym} 270 -1680 0 0 {name=V6 value=0}
C {vsource.sym} 500 -1770 0 0 {name=V8 value=0}
C {gnd.sym} 20 -2240 0 0 {name=l2695 lab=GND}
C {lab_pin.sym} 20 -2300 0 0 {name=l2696 sig_type=std_logic lab=WE0}
C {vsource.sym} 20 -2270 0 0 {name=V24 value="PULSE(0V 3.3 8n 50p 50p 4n 12n)"}
C {gnd.sym} 20 -1960 0 0 {name=l2697 lab=GND}
C {lab_pin.sym} 20 -2020 0 0 {name=l2698 sig_type=std_logic lab=WE3}
C {gnd.sym} 20 -2150 0 0 {name=l2699 lab=GND}
C {lab_pin.sym} 20 -2210 0 0 {name=l2700 sig_type=std_logic lab=WE1}
C {vsource.sym} 20 -2180 0 0 {name=V25 value=0}
C {vsource.sym} 20 -1990 0 0 {name=V26 value=0}
C {gnd.sym} 20 -2050 0 0 {name=l2689 lab=GND}
C {lab_pin.sym} 20 -2110 0 0 {name=l2690 sig_type=std_logic lab=WE2}
C {vsource.sym} 20 -2080 0 0 {name=V21 value=0}
C {code_shown.sym} -910 -2440 0 0 {name=s1 only_toplevel=false value="
.control
save all
tran 25p 90n
write tb_RAM32_final.raw
.endc
"}
C {devices/code_shown.sym} -610 -2430 0 0 {name=MODELS only_toplevel=true
format="tcleval( @value )"
value="
.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical
"}
C {lab_wire.sym} -3730 210 0 0 {name=l790 sig_type=std_logic lab=muxout0}
C {lab_wire.sym} -3340 200 0 0 {name=l791 sig_type=std_logic lab=muxout1}
C {lab_wire.sym} -2950 200 0 0 {name=l792 sig_type=std_logic lab=muxout2}
C {lab_wire.sym} -2560 200 0 0 {name=l793 sig_type=std_logic lab=muxout3}
C {lab_wire.sym} -2170 200 0 0 {name=l794 sig_type=std_logic lab=muxout4}
C {lab_wire.sym} -1780 190 0 0 {name=l795 sig_type=std_logic lab=muxout5}
C {lab_wire.sym} -1390 200 0 0 {name=l796 sig_type=std_logic lab=muxout6}
C {lab_wire.sym} -1000 200 0 0 {name=l797 sig_type=std_logic lab=muxout7}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2060 -2380 0 0 {name=X_inv75 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2220 -2380 0 0 {name=X_inv76 NF=16}
C {lab_wire.sym} 2200 -2460 0 0 {name=l2509 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2200 -2380 0 0 {name=l2510 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2030 -2420 0 0 {name=l2511 sig_type=std_logic lab=Di0}
C {lab_wire.sym} 2380 -2420 0 0 {name=l2512 sig_type=std_logic lab=di0_buf}
C {lab_wire.sym} 2440 -2420 0 0 {name=l2515 sig_type=std_logic lab=Di1}
C {lab_wire.sym} 2780 -2420 0 0 {name=l2516 sig_type=std_logic lab=di1_buf}
C {lab_wire.sym} 2840 -2420 0 0 {name=l2519 sig_type=std_logic lab=Di2}
C {lab_wire.sym} 3180 -2420 0 0 {name=l2520 sig_type=std_logic lab=di2_buf}
C {lab_wire.sym} 3240 -2420 0 0 {name=l2523 sig_type=std_logic lab=Di3}
C {lab_wire.sym} 3580 -2420 0 0 {name=l2524 sig_type=std_logic lab=di3_buf}
C {lab_wire.sym} 2200 -2330 0 0 {name=l2525 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2200 -2250 0 0 {name=l2526 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2030 -2290 0 0 {name=l2527 sig_type=std_logic lab=Di4}
C {lab_wire.sym} 2380 -2290 0 0 {name=l2528 sig_type=std_logic lab=di4_buf}
C {lab_wire.sym} 2440 -2290 0 0 {name=l2531 sig_type=std_logic lab=Di5}
C {lab_wire.sym} 2780 -2290 0 0 {name=l2532 sig_type=std_logic lab=di5_buf}
C {lab_wire.sym} 2840 -2290 0 0 {name=l2535 sig_type=std_logic lab=Di6}
C {lab_wire.sym} 3180 -2290 0 0 {name=l2536 sig_type=std_logic lab=di6_buf}
C {lab_wire.sym} 3240 -2290 0 0 {name=l2539 sig_type=std_logic lab=Di7}
C {lab_wire.sym} 3580 -2290 0 0 {name=l2540 sig_type=std_logic lab=di7_buf}
C {lab_wire.sym} 2200 -2200 0 0 {name=l2541 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2200 -2120 0 0 {name=l2542 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2030 -2160 0 0 {name=l2543 sig_type=std_logic lab=Di8}
C {lab_wire.sym} 2380 -2160 0 0 {name=l2544 sig_type=std_logic lab=di8_buf}
C {lab_wire.sym} 2440 -2160 0 0 {name=l2547 sig_type=std_logic lab=Di9}
C {lab_wire.sym} 2780 -2160 0 0 {name=l2548 sig_type=std_logic lab=di9_buf}
C {lab_wire.sym} 2840 -2160 0 0 {name=l2551 sig_type=std_logic lab=Di10}
C {lab_wire.sym} 3180 -2160 0 0 {name=l2552 sig_type=std_logic lab=di10_buf}
C {lab_wire.sym} 3240 -2160 0 0 {name=l2555 sig_type=std_logic lab=Di11}
C {lab_wire.sym} 3580 -2160 0 0 {name=l2556 sig_type=std_logic lab=di11_buf}
C {lab_wire.sym} 2200 -2070 0 0 {name=l2557 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2200 -1990 0 0 {name=l2558 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2030 -2030 0 0 {name=l2559 sig_type=std_logic lab=Di12}
C {lab_wire.sym} 2380 -2030 0 0 {name=l2560 sig_type=std_logic lab=di12_buf}
C {lab_wire.sym} 2440 -2030 0 0 {name=l2563 sig_type=std_logic lab=Di13}
C {lab_wire.sym} 2780 -2030 0 0 {name=l2564 sig_type=std_logic lab=di13_buf}
C {lab_wire.sym} 2840 -2030 0 0 {name=l2567 sig_type=std_logic lab=Di14}
C {lab_wire.sym} 3180 -2030 0 0 {name=l2568 sig_type=std_logic lab=di14_buf}
C {lab_wire.sym} 3240 -2030 0 0 {name=l2571 sig_type=std_logic lab=Di15}
C {lab_wire.sym} 3580 -2030 0 0 {name=l2572 sig_type=std_logic lab=di15_buf}
C {lab_wire.sym} 2200 -1940 0 0 {name=l2573 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2200 -1860 0 0 {name=l2574 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2030 -1900 0 0 {name=l2575 sig_type=std_logic lab=Di16}
C {lab_wire.sym} 2380 -1900 0 0 {name=l2576 sig_type=std_logic lab=di16_buf}
C {lab_wire.sym} 2440 -1900 0 0 {name=l2579 sig_type=std_logic lab=Di17}
C {lab_wire.sym} 2780 -1900 0 0 {name=l2580 sig_type=std_logic lab=di17_buf}
C {lab_wire.sym} 2840 -1900 0 0 {name=l2583 sig_type=std_logic lab=Di18}
C {lab_wire.sym} 3180 -1900 0 0 {name=l2584 sig_type=std_logic lab=di18_buf}
C {lab_wire.sym} 3240 -1900 0 0 {name=l2587 sig_type=std_logic lab=Di19}
C {lab_wire.sym} 3580 -1900 0 0 {name=l2588 sig_type=std_logic lab=di19_buf}
C {lab_wire.sym} 2200 -1810 0 0 {name=l2589 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2200 -1730 0 0 {name=l2590 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2030 -1770 0 0 {name=l2591 sig_type=std_logic lab=Di20}
C {lab_wire.sym} 2380 -1770 0 0 {name=l2592 sig_type=std_logic lab=di20_buf}
C {lab_wire.sym} 2440 -1770 0 0 {name=l2595 sig_type=std_logic lab=Di21}
C {lab_wire.sym} 2780 -1770 0 0 {name=l2596 sig_type=std_logic lab=di21_buf}
C {lab_wire.sym} 2840 -1770 0 0 {name=l2599 sig_type=std_logic lab=Di22}
C {lab_wire.sym} 3180 -1770 0 0 {name=l2600 sig_type=std_logic lab=di22_buf}
C {lab_wire.sym} 3240 -1770 0 0 {name=l2603 sig_type=std_logic lab=Di23}
C {lab_wire.sym} 3580 -1770 0 0 {name=l2604 sig_type=std_logic lab=di23_buf}
C {lab_wire.sym} 2200 -1680 0 0 {name=l2605 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2200 -1600 0 0 {name=l2606 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2030 -1640 0 0 {name=l2607 sig_type=std_logic lab=Di24}
C {lab_wire.sym} 2380 -1640 0 0 {name=l2608 sig_type=std_logic lab=di24_buf}
C {lab_wire.sym} 2440 -1640 0 0 {name=l2611 sig_type=std_logic lab=Di25}
C {lab_wire.sym} 2780 -1640 0 0 {name=l2612 sig_type=std_logic lab=di25_buf}
C {lab_wire.sym} 2840 -1640 0 0 {name=l2615 sig_type=std_logic lab=Di26}
C {lab_wire.sym} 3180 -1640 0 0 {name=l2616 sig_type=std_logic lab=di26_buf}
C {lab_wire.sym} 3240 -1640 0 0 {name=l2619 sig_type=std_logic lab=Di27}
C {lab_wire.sym} 3580 -1640 0 0 {name=l2620 sig_type=std_logic lab=di27_buf}
C {lab_wire.sym} 2200 -1550 0 0 {name=l2621 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2200 -1470 0 0 {name=l2622 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2030 -1510 0 0 {name=l2623 sig_type=std_logic lab=Di28}
C {lab_wire.sym} 2380 -1510 0 0 {name=l2624 sig_type=std_logic lab=di28_buf}
C {lab_wire.sym} 2440 -1510 0 0 {name=l2627 sig_type=std_logic lab=Di29}
C {lab_wire.sym} 2780 -1510 0 0 {name=l2628 sig_type=std_logic lab=di29_buf}
C {lab_wire.sym} 2840 -1510 0 0 {name=l2631 sig_type=std_logic lab=Di30}
C {lab_wire.sym} 3180 -1510 0 0 {name=l2632 sig_type=std_logic lab=di30_buf}
C {lab_wire.sym} 3240 -1510 0 0 {name=l2635 sig_type=std_logic lab=Di31}
C {lab_wire.sym} 3580 -1510 0 0 {name=l2636 sig_type=std_logic lab=di31_buf}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2060 -2250 0 0 {name=X_inv83 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2060 -2120 0 0 {name=X_inv91 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2060 -1990 0 0 {name=X_inv99 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2060 -1860 0 0 {name=X_inv107 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2060 -1730 0 0 {name=X_inv115 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2060 -1600 0 0 {name=X_inv123 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2060 -1470 0 0 {name=X_inv131 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2220 -2250 0 0 {name=X_inv84 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2220 -2120 0 0 {name=X_inv92 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2220 -1990 0 0 {name=X_inv100 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2220 -1860 0 0 {name=X_inv108 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2220 -1730 0 0 {name=X_inv116 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2220 -1600 0 0 {name=X_inv124 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2220 -1470 0 0 {name=X_inv132 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2460 -2380 0 0 {name=X_inv77 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2620 -2380 0 0 {name=X_inv78 NF=16}
C {lab_wire.sym} 2600 -2460 0 0 {name=l2513 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2600 -2380 0 0 {name=l2514 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2600 -2330 0 0 {name=l2529 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2600 -2250 0 0 {name=l2530 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2600 -2200 0 0 {name=l2545 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2600 -2120 0 0 {name=l2546 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2600 -2070 0 0 {name=l2561 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2600 -1990 0 0 {name=l2562 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2600 -1940 0 0 {name=l2577 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2600 -1860 0 0 {name=l2578 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2600 -1810 0 0 {name=l2593 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2600 -1730 0 0 {name=l2594 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2600 -1680 0 0 {name=l2609 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2600 -1600 0 0 {name=l2610 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 2600 -1550 0 0 {name=l2625 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 2600 -1470 0 0 {name=l2626 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2460 -2250 0 0 {name=X_inv85 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2460 -2120 0 0 {name=X_inv86 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2460 -1990 0 0 {name=X_inv93 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2460 -1860 0 0 {name=X_inv94 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2460 -1730 0 0 {name=X_inv101 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2460 -1600 0 0 {name=X_inv102 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2460 -1470 0 0 {name=X_inv109 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2620 -2250 0 0 {name=X_inv110 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2620 -2120 0 0 {name=X_inv117 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2620 -1990 0 0 {name=X_inv118 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2620 -1860 0 0 {name=X_inv125 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2620 -1730 0 0 {name=X_inv126 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2620 -1600 0 0 {name=X_inv133 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2620 -1470 0 0 {name=X_inv134 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2860 -2380 0 0 {name=X_inv79 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3020 -2380 0 0 {name=X_inv80 NF=16}
C {lab_wire.sym} 3000 -2460 0 0 {name=l2517 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3000 -2380 0 0 {name=l2518 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3000 -2330 0 0 {name=l2521 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3000 -2250 0 0 {name=l2522 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3000 -2200 0 0 {name=l2533 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3000 -2120 0 0 {name=l2534 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3000 -2070 0 0 {name=l2537 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3000 -1990 0 0 {name=l2538 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3000 -1940 0 0 {name=l2549 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3000 -1860 0 0 {name=l2550 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3000 -1810 0 0 {name=l2553 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3000 -1730 0 0 {name=l2554 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3000 -1680 0 0 {name=l2565 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3000 -1600 0 0 {name=l2566 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3000 -1550 0 0 {name=l2569 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3000 -1470 0 0 {name=l2570 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2860 -2250 0 0 {name=X_inv81 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2860 -2120 0 0 {name=X_inv82 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2860 -1990 0 0 {name=X_inv87 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2860 -1860 0 0 {name=X_inv88 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2860 -1730 0 0 {name=X_inv89 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2860 -1600 0 0 {name=X_inv90 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 2860 -1470 0 0 {name=X_inv95 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3020 -2250 0 0 {name=X_inv96 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3020 -2120 0 0 {name=X_inv97 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3020 -1990 0 0 {name=X_inv98 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3020 -1860 0 0 {name=X_inv103 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3020 -1730 0 0 {name=X_inv104 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3020 -1600 0 0 {name=X_inv105 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3020 -1470 0 0 {name=X_inv106 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3260 -2380 0 0 {name=X_inv111 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3420 -2380 0 0 {name=X_inv112 NF=16}
C {lab_wire.sym} 3400 -2460 0 0 {name=l2581 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3400 -2380 0 0 {name=l2582 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3400 -2330 0 0 {name=l2585 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3400 -2250 0 0 {name=l2586 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3400 -2200 0 0 {name=l2597 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3400 -2120 0 0 {name=l2598 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3400 -2070 0 0 {name=l2601 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3400 -1990 0 0 {name=l2602 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3400 -1940 0 0 {name=l2613 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3400 -1860 0 0 {name=l2614 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3400 -1810 0 0 {name=l2617 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3400 -1730 0 0 {name=l2618 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3400 -1680 0 0 {name=l2629 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3400 -1600 0 0 {name=l2630 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 3400 -1550 0 0 {name=l2633 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 3400 -1470 0 0 {name=l2634 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3260 -2250 0 0 {name=X_inv113 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3260 -2120 0 0 {name=X_inv114 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3260 -1990 0 0 {name=X_inv119 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3260 -1860 0 0 {name=X_inv120 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3260 -1730 0 0 {name=X_inv121 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3260 -1600 0 0 {name=X_inv122 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3260 -1470 0 0 {name=X_inv127 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3420 -2250 0 0 {name=X_inv128 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3420 -2120 0 0 {name=X_inv129 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3420 -1990 0 0 {name=X_inv130 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3420 -1860 0 0 {name=X_inv135 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3420 -1730 0 0 {name=X_inv136 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3420 -1600 0 0 {name=X_inv137 NF=16}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 3420 -1470 0 0 {name=X_inv138 NF=16}
C {gnd.sym} -240 -2240 0 0 {name=l798 lab=GND}
C {lab_pin.sym} -240 -2300 0 0 {name=l799 sig_type=std_logic lab=RE}
C {vsource.sym} -240 -2270 0 0 {name=V17 value="PULSE(0V 3.3 12n 50p 50p 4n 12n)"}
C {lab_pin.sym} -1320 -400 0 0 {name=l800 sig_type=std_logic lab=RE_buf}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1610 -1590 0 0 {name=X_inv22 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1450 -1590 0 0 {name=X_inv23 NF=8}
C {lab_wire.sym} -1470 -1670 0 0 {name=l801 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1470 -1590 0 0 {name=l802 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1620 -1630 0 0 {name=l803 sig_type=std_logic lab=A3}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1610 -1440 0 0 {name=X_inv24 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1450 -1440 0 0 {name=X_inv25 NF=8}
C {lab_wire.sym} -1470 -1520 0 0 {name=l805 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1470 -1440 0 0 {name=l806 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1620 -1480 0 0 {name=l807 sig_type=std_logic lab=A4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1280 -1590 0 0 {name=X_inv26 NF=32}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1120 -1590 0 0 {name=X_inv27 NF=28}
C {lab_wire.sym} -1140 -1670 0 0 {name=l804 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1140 -1590 0 0 {name=l808 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1280 -1440 0 0 {name=X_inv28 NF=32}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1120 -1440 0 0 {name=X_inv29 NF=28}
C {lab_wire.sym} -1140 -1520 0 0 {name=l809 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1140 -1440 0 0 {name=l810 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1120 -1720 0 0 {name=l811 sig_type=std_logic lab=A3_bar}
C {lab_wire.sym} -960 -1630 2 0 {name=l812 sig_type=std_logic lab=A3_buf}
C {lab_wire.sym} -960 -1480 2 0 {name=l813 sig_type=std_logic lab=A4_buf}
C {lab_wire.sym} -1120 -1400 0 0 {name=l814 sig_type=std_logic lab=A4_bar}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1620 -1940 0 0 {name=X_inv30 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1460 -1940 0 0 {name=X_inv31 NF=8}
C {lab_wire.sym} -1480 -2020 0 0 {name=l815 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1480 -1940 0 0 {name=l816 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1630 -1980 0 0 {name=l817 sig_type=std_logic lab=A1}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1620 -1790 0 0 {name=X_inv32 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1460 -1790 0 0 {name=X_inv33 NF=8}
C {lab_wire.sym} -1480 -1870 0 0 {name=l818 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1480 -1790 0 0 {name=l819 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1630 -1830 0 0 {name=l820 sig_type=std_logic lab=A2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1630 -2100 0 0 {name=X_inv34 NF=2}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -1470 -2100 0 0 {name=X_inv35 NF=8}
C {lab_wire.sym} -1490 -2180 0 0 {name=l821 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -1490 -2100 0 0 {name=l822 sig_type=std_logic lab=VSS}
C {lab_wire.sym} -1640 -2140 0 0 {name=l823 sig_type=std_logic lab=A0}
C {lab_wire.sym} -1310 -2140 2 0 {name=l824 sig_type=std_logic lab=A0_buf}
C {lab_wire.sym} -1300 -1980 2 0 {name=l825 sig_type=std_logic lab=A1_buf}
C {lab_wire.sym} -1300 -1830 2 0 {name=l826 sig_type=std_logic lab=A2_buf}
C {xschem_lib/DFFRAM_full_custom/inv.sym} -610 -340 0 0 {name=X_inv36 NF=36}
C {lab_wire.sym} -550 -420 1 0 {name=l827 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -550 -340 2 0 {name=l828 sig_type=std_logic lab=VSS}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 30 -340 0 0 {name=X_inv37 NF=4}
C {xschem_lib/DFFRAM_full_custom/inv.sym} 190 -340 0 0 {name=X_inv38 NF=16}
C {lab_wire.sym} 170 -420 0 0 {name=l829 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 170 -340 0 0 {name=l830 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 20 -380 0 0 {name=l831 sig_type=std_logic lab=RE}
C {lab_wire.sym} 350 -380 2 0 {name=l832 sig_type=std_logic lab=RE_buf}
C {lab_wire.sym} 1000 -1260 1 0 {name=l833 sig_type=std_logic lab=RE_buf}
C {lab_wire.sym} 1530 -1260 1 0 {name=l834 sig_type=std_logic lab=RE_buf}
C {lab_wire.sym} 2070 -1260 1 0 {name=l835 sig_type=std_logic lab=RE_buf}
C {lab_wire.sym} 2590 -1260 1 0 {name=l836 sig_type=std_logic lab=RE_buf}
C {vsource.sym} 260 -2190 0 0 {name=V1 value="PULSE(0V 3.3 8n 50p 50p 12n 24n)"}
C {vsource.sym} 260 -2100 0 0 {name=V11 value="PULSE(0V 3.3 8n 50p 50p 12n 24n)"}
C {vsource.sym} 260 -2010 0 0 {name=V12 value="PULSE(0V 3.3 8n 50p 50p 12n 24n)"}
C {vsource.sym} 490 -2280 0 0 {name=V13 value="PULSE(0V 3.3 8n 50p 50p 12n 24n)"}
C {vsource.sym} 490 -2190 0 0 {name=V14 value="PULSE(0V 3.3 8n 50p 50p 12n 24n)"}
C {vsource.sym} 490 -2100 0 0 {name=V15 value="PULSE(0V 3.3 8n 50p 50p 12n 24n)"}
C {vsource.sym} 490 -2010 0 0 {name=V16 value="PULSE(0V 3.3 8n 50p 50p 12n 24n)"}
C {vsource.sym} 500 -1860 0 0 {name=V9 value="PULSE(0V 3.3 40n 50p 50p 36n 72n)"}
C {vsource.sym} 500 -1680 0 0 {name=V7 value=3.3}
